# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4fe7ee4d85c8089bf2ee9ee21825a2e"
SRC_URI[sha256sum] = "2417350135add66620ef638c95589da9353ed674f645d5b25da9ca6354513456"
