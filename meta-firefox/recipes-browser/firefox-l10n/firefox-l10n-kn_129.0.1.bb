# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce77bb5ae113ccb67287f11018fd6ad"
SRC_URI[sha256sum] = "0cecd452969a4e96aa6b3326e95d2fad0554f16d6b02738a95567595e60e6aac"
