# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d58627e4469a1015dfa1e6ba565bd738"
SRC_URI[sha256sum] = "4df07f9071fe2e4319f653886f1f036aa26735b95b661b21dc4711422ae8ba69"
