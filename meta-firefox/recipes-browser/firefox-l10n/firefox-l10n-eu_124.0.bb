# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4314090339e2f28164dd879de47a6b8"
SRC_URI[sha256sum] = "c310ae86de7112334cefae5a9dc69ecfa24a2cde84f8adefd2ff3f8138976f28"
