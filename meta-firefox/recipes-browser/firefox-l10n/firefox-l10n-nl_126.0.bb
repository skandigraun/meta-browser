# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa757a398073db1d0e45921dc9078e24"
SRC_URI[sha256sum] = "59500a8b87a6dacb6d89d7318cff455843fe3428fe1254ccee844d81098abb3e"
