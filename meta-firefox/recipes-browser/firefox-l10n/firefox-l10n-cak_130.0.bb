# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38941be165287f52c0e50a35d88c7fd1"
SRC_URI[sha256sum] = "5fe8191e99ad57f832a528df91db6e7a51af41f48c0812e69abf124cb63da85b"
