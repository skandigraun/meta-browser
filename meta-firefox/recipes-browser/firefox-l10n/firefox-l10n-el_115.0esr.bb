# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cab87dcb08a9a1c147cb79bee3f438a5"
SRC_URI[sha256sum] = "a3c82383a6b91254d677245b30ca6a4c43ef053f0384fa00e49cee0cdd2b0485"
