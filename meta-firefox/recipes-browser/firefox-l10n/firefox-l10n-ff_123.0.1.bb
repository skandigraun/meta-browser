# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d335b1e449c979a7ae84295e0240e15"
SRC_URI[sha256sum] = "63cd55c6ddffdce3e4e91f7b77590a58e2a722c9e95307ff7b16ebcf476e5fc6"
