# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "714274255dbcd8e249d0e060a94f78ac"
SRC_URI[sha256sum] = "f090f78b7a12ad485ff80604c30a2a386309c0baf0cd5410dbae54e2277d0e52"
