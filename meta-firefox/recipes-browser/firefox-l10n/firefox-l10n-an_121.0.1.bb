# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d82ad0701b66ff623abf70cc0bb07080"
SRC_URI[sha256sum] = "dfc4b3861fd21b7fca2ed7be17fe8d45060d06dcb9b8f311a0be51b7daeece76"
