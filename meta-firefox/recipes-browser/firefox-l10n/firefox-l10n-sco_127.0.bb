# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b94184b9d6d281cfb1204d4eb6864322"
SRC_URI[sha256sum] = "d955311545702fa68dfdb4b96246e304fc5c1be4625c5cc0edbc2f08d0cc1fa0"
