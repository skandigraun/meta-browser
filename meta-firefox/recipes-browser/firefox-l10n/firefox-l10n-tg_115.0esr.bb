# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f340ce76948b0bd4aeff26ecbb0c0674"
SRC_URI[sha256sum] = "bc3d2c65f2e3dc04d8f0e26b4026b14f6c7bdb923a67f831c44b73d662e510f6"
