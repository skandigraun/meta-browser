# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f75ae65593aaa2a73f8c4bcfe50e768"
SRC_URI[sha256sum] = "a92361e0ef301264847fb2b196f0effe24f1507d4b3a2e83c470473993207b24"
