# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55a96db7498a5a161deefd83021962fe"
SRC_URI[sha256sum] = "7746301d09f3136d275709cb873a87872c6c2a2e513b8a71d1f45f5a28954d55"
