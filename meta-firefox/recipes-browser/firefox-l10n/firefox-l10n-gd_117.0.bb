# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4648358edf89948cf6e85d6204d63f9a"
SRC_URI[sha256sum] = "56ed79f66699df5a15982b323857e2bc2e88c4bf3c6d0d9fa1e1b3ff5448f482"
