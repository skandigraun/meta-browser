# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c01bfc97d7c1ad712c983327effd5750"
SRC_URI[sha256sum] = "ba6a082b4c41594d1fa671269357f7f814c169f0c62e343164ea86957cb0c748"
