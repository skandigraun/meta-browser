# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3167ded6fd10c1b0d5283348373b632a"
SRC_URI[sha256sum] = "9e2476c23e1e0358b20304d04898cbf508e5659347490e7b32aad4a57a9f9254"
