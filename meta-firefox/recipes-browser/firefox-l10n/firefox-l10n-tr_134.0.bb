# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12e4b4944b2c2b534172115e664a1edb"
SRC_URI[sha256sum] = "517ed762de1a4ac10dc0059bcae60aa8e40f4e45da4a04966b93e8ad180626f2"
