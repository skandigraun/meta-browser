# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5662ff4d236497c0b54fcf6f6926deea"
SRC_URI[sha256sum] = "092fae7dde0149de20a2d37e2edc7878dcab1336c22ee2cca172be096da4b78a"
