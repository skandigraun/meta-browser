# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3422dce64d65c6ce9d72101b40c406a"
SRC_URI[sha256sum] = "0f2583d68ba29bbc0c4f72fd0eb5033b7d624f4abaf48bdbb31df899513cb52f"
