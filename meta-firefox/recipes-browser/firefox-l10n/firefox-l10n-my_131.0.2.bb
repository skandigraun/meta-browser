# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9a99c384015d1a1cbc3833a19695e31"
SRC_URI[sha256sum] = "1ee5f99ea6a90ed308b2ef9f3ff9f39bb8a9fc438ceaed61d1a5bd0960ee7e7f"
