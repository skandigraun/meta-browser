# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9b0bba188f44bab3bd965893d88bc43"
SRC_URI[sha256sum] = "51c862de9efbb501b4c5d9ff948bd5e288a42307b18126f9e052d62ff5017e29"
