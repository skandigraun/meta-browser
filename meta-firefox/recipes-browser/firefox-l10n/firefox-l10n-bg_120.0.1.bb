# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59460b83a0a43317f89a93d451235903"
SRC_URI[sha256sum] = "e4c0f46fb07662d965e76edfb3b0438b195e89b2892cdc6f8227b85f5ab0d346"
