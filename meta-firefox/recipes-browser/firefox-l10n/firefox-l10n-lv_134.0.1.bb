# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ac45f1178a0188267b834280d2381cf"
SRC_URI[sha256sum] = "ba5c1f1fb2e89804dfbc3e30b0c9100023c072d289d9296a1a30885c04f957de"
