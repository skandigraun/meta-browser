# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d894f1892f1b8d62a18ebd779ff5f6"
SRC_URI[sha256sum] = "7a4446068f0b3e40f1a5364219618c71e539da13295b882333957e00fb992c25"
