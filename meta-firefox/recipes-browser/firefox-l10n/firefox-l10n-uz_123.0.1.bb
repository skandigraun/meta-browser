# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c851b34833f282c7a6f1d57d250174c"
SRC_URI[sha256sum] = "ec529c2a85d9d90a494bb9690947f59404923bc42e701aa2c437ed510083b3fc"
