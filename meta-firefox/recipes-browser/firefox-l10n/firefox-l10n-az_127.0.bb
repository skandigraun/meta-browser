# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "999fcd35383780cb983fb3d7e2c3208c"
SRC_URI[sha256sum] = "7e4686881e77369c4d5b98d9d1d59dd8d9e620d744c550c3f3afc6af413b3779"
