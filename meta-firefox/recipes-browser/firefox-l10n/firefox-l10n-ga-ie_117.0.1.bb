# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a237c486efbefd7d4131e085028d549"
SRC_URI[sha256sum] = "ecb57812eafd8095ffbe7080703e6aeb0519c66c7e5f14e7a99dd7342b9c4c2a"
