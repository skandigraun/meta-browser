# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de9561287d912e9b1d65f43e79259eff"
SRC_URI[sha256sum] = "624755ade84e687aca5b80188195ae1761f982409be2fe403c1eb149ec7b8b91"
