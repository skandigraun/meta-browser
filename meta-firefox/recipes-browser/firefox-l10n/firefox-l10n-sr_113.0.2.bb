# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adc389db9423861c538311114d6a13aa"
SRC_URI[sha256sum] = "7ad2c2d21edc509e3568f75d82b1a0ea3b302a7c6039e005688be0c4de0ecb2e"
