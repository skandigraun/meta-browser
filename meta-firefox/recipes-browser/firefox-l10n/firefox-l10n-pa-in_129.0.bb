# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84091091668e89dd775f6b62b57d25f5"
SRC_URI[sha256sum] = "7a0f87d4373e5cdad7443c79b1b909d909ab92fa6ba5967750f062da23b9bba9"
