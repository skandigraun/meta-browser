# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b1fc39eb79817acdd96c53e08b036f8"
SRC_URI[sha256sum] = "19a52bc9f2099b0fbb6fe8c98c6bc7a262d8070efa6599c7fb9ff24d6c16d5a6"
