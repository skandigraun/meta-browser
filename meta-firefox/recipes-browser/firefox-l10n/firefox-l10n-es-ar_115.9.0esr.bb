# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7e6eeb153ee5d61c27241143c3a675e"
SRC_URI[sha256sum] = "3e4240cfc87d586ffa09c42a9afcffb5c3e7a273cbb011ed1e8523af9e0dd1cf"
