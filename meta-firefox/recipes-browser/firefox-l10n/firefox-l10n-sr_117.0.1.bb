# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44f3516833fb4b200a0fc053aa8f383f"
SRC_URI[sha256sum] = "89a2f36ed5ed22e73cfa85ff192d8f39fab429cc53aa514ee135a971461204ca"
