# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32a00a6bfea774768e5441cd8980ffd1"
SRC_URI[sha256sum] = "825b6ce31f6829c1198db4d849accdf61f4bcd44165387fa1c4196bc8160b1f9"
