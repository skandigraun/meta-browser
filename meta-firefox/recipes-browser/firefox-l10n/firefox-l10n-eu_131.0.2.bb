# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f380fb5f68d4757d411eb13b23914a8a"
SRC_URI[sha256sum] = "4e3698f257f124ecc84efc19ad5609859a1ee63cd814ee4455d6042e6e84e137"
