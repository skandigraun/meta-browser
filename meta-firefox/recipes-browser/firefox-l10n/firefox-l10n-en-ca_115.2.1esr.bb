# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c0195b753b0f6193234b0b7129d5a48"
SRC_URI[sha256sum] = "3bc7bdd1c2638f5b006fa8ad9ce6681e4b6421c3e3a1d44d6a6022814ad32db3"
