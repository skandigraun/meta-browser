# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b01e06f3bed95690e2c952361834bbc3"
SRC_URI[sha256sum] = "024c5b129a0d337e903098cfce363c5a6f82161c9979ba524bb94b04f34c9513"
