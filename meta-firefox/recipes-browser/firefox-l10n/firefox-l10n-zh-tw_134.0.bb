# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa0188c2b42f2441a17a16462f5f1ddb"
SRC_URI[sha256sum] = "ec90a5b5471673f10c4771f071a90b1177257a8dfebdaccf19ffa27fc80a1d19"
