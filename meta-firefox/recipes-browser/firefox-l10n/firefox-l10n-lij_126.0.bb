# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea26b671d694b1b8b4c67b8705aedf1b"
SRC_URI[sha256sum] = "d9c53cd2db1c5b5a4337677a0962af5ba17868ca119f586c0c21b7ec9e1e9461"
