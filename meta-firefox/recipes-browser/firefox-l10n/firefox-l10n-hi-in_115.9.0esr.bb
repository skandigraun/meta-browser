# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0384b746a9685547e677fc0e52aac375"
SRC_URI[sha256sum] = "a44d6f0064d383f9bb77fdf304dee8db9691e075fde16b780c1526189593e9ff"
