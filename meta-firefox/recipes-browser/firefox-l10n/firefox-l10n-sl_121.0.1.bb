# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24040ad72c78c86fa039589daea4916c"
SRC_URI[sha256sum] = "954c057129367e2dc8d7d5a6223c31e90962f5eb072ab07a3d22b6094ce4918c"
