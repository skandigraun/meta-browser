# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4869ee1aa4825f2b3807c78d26c2888c"
SRC_URI[sha256sum] = "2c3886c5216050ee1bd0693db8eadc7c585b14787000b6f6d5a103fb5c1dd179"
