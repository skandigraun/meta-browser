# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a218b58ade222d5ca4706d9ab0a79755"
SRC_URI[sha256sum] = "3f5ce4a498b8be9eb1307ed3dfdb0a5986fbd4bc9c8265be2c99f2e585decc09"
