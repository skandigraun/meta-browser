# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "802c9876b699a67254019c5dc5eb017c"
SRC_URI[sha256sum] = "9f3f824d1da6c561c5f99488000322ab9837643119a761e90d986ce3c4c079ae"
