# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db6df4a6814d6ec7c0f0a42a558bb13c"
SRC_URI[sha256sum] = "350ae9853b230d4105bdd8ff2cafbdfde5c3edd9b1f0e9aafeb9fe46c54a8c6b"
