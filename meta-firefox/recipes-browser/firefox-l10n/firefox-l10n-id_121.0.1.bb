# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be7d5c0a3f1999db555b777db2649ae7"
SRC_URI[sha256sum] = "fe0a476100dd582249aaabb2154529ba63e327d237c3e4291a6ebf7620a7d852"
