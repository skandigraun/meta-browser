# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "632625b78e0cbb9ca3175e0a857753ae"
SRC_URI[sha256sum] = "eea74c715da0c685608db991494cfa32004be899bf96f5efb5274ef22ef673a2"
