# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3ef2df7e53313b1a90c665499f85404"
SRC_URI[sha256sum] = "a87c0b5da7c38c5bb85d1b3e1b503ccb63fc9f8908ad6cae5323ab328d77b0b8"
