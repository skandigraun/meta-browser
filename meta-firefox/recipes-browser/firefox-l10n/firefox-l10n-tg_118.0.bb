# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67004dcf57fb36facec91e88de498871"
SRC_URI[sha256sum] = "d35a3d743328eeff4f9babda47e253d2bfc4e57e43dd6c9151fa9eb5ba81dac5"
