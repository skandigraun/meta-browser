# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8514d632c1a5b347d07b41a2ba7bfdd8"
SRC_URI[sha256sum] = "01222a5ffe6f39673ce366428a5934478258fa852ad8582ca4f8cade24af3dba"
