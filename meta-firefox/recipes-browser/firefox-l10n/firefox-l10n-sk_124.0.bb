# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "534e8c770895ea646d265817e237b929"
SRC_URI[sha256sum] = "cd7acdf1dda2a5fea32b6d5c1967f35ef4b9819cbfe148b6661f68719082c208"
