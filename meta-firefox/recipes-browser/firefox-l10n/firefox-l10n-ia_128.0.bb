# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d83eb1d79d5238b7c79be2e5f590aa9"
SRC_URI[sha256sum] = "e624d14e8379d1e856d52e0e5658092f8ec0d140b77ead223f7c05b1b673e8ab"
