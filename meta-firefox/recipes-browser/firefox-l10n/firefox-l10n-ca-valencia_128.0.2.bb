# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "325aa57eb66d1c82975cbe65827959ed"
SRC_URI[sha256sum] = "8e2137656892222ac39f4a1a91efb244ae59ff4acbc83b2a60b00911848d0e62"
