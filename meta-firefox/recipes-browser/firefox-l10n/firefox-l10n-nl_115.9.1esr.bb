# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c80ed5c7939e1c22ffb27eb2f58857"
SRC_URI[sha256sum] = "de4a05e8a492d0ed489ece9b1ed8c3bcbe7eda277806a683b3dc0a407e357a68"
