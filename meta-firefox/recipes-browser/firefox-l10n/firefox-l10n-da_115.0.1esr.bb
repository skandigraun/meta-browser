# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86750daa8ba0118bb8dc08a51853660b"
SRC_URI[sha256sum] = "bc6bd21e6925c6083daf7a23d44f9a6b551dee925ae8fd288a91eefd8884562f"
