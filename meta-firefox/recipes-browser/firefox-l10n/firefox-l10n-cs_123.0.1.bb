# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d081c9fe8410364ed1c26f9610c5f7b5"
SRC_URI[sha256sum] = "6691633baef48a3457bec41baec2f11661d9801778948a4e314d63b5974d7f5c"
