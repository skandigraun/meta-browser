# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "718dda46e3e42d78520e45c3df99bd02"
SRC_URI[sha256sum] = "3758d7b079aa29b3dab971049a9e940eb907c5ef27429fa71de805f238a0881a"
