# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84eae2c5b0983a602dd839ae490180be"
SRC_URI[sha256sum] = "02ba5620678d99fded198f2ee8a1a22fbe48b7adba52677af9252b097bb8e56d"
