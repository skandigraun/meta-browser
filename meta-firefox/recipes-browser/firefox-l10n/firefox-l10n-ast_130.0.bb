# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bbaae0dfc90b6a0af1cd9b89d8c7ae2"
SRC_URI[sha256sum] = "c5c55f05f1f5bb418f03fae02bf9cff77136a93b50fd7246e09b673c07cade32"
