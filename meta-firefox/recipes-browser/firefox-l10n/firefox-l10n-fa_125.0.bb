# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "876a7df1589628a3473720b55dfd2d2a"
SRC_URI[sha256sum] = "acb584fb3c2291911910ec2c55c07c5a98288eca37a256beca874c1d95c5622e"
