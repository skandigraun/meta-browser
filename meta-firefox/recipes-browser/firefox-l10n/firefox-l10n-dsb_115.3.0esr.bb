# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0dfc0df0370f07515c25b8ac4e7a942"
SRC_URI[sha256sum] = "6f5368399a4b1e4aeed69f8daedc75923c820e901579514af3f1e75d613a2fc0"
