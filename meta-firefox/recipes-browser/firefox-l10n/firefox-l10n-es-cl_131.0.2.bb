# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547fe416a78a2352619264ab903cc118"
SRC_URI[sha256sum] = "65351d059eb11c5a1516026b20b7a5473b9d77ada4ab04af6038c711cbc5ee56"
