# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeaf52e95cde932efaeb60e5e29fc8db"
SRC_URI[sha256sum] = "8344af9f87082d03633fab9e21070fb06b85530e43d1b4b4951d503f618c59a5"
