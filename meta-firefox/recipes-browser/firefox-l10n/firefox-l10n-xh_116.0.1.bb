# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30cee37fb3ef1c08b696940b05a5ce93"
SRC_URI[sha256sum] = "7bce17fbf09e5efe076c1bc7bc7a6fd501294be44371dfc33094a77fa5f99a6d"
