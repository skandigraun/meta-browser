# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "704c01b4e189f9374036af22caff1b96"
SRC_URI[sha256sum] = "c8d2b96b1734448559f642ac7ee03c637cb9db44935e6e27bced68330a204aee"
