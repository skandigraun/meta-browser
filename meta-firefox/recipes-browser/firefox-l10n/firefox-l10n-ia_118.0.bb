# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76d0c744f8580ac25af5e7c9e3197bd7"
SRC_URI[sha256sum] = "b8e7392ebb5ae39c51585854374a9e60dbf83a4c42088954170ba10a07592b1c"
