# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2c318fd8615cb4fdfc21cf0d9a08177"
SRC_URI[sha256sum] = "90912dde910b350f6c9a169fee42638d0ab4f551eef6b4b583b22a6bd4e11bb7"
