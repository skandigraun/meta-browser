# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "133af91aeeddcc33b94b6fea724a7c77"
SRC_URI[sha256sum] = "f0a6f0a8c9bc622ce05b68ba94dc1659fe62ecbda47d349f76794f3935585f38"
