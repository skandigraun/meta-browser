# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d24afb4e5551834ae9fd6574bf30bce6"
SRC_URI[sha256sum] = "6a098ccf91748ed66691e32ffed436c88f46d52e969a156a1cb4685a1e38a758"
