# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d5b660e3830d9d11b9a91c0ec4aff26"
SRC_URI[sha256sum] = "2d0af54404af074a574d2e4355c4c686d70967d23f4b088e5f328361de05d5e8"
