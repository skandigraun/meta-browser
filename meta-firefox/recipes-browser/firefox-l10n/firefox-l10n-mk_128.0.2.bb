# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8186304f29642b99da5f39b59a27308"
SRC_URI[sha256sum] = "05cbeeece481dadc2bdce83eb843f2820f307108f8ca84eb52015425c72089fc"
