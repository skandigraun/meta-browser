# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0e193e95b6d8fb57e74c755b8f2d65c"
SRC_URI[sha256sum] = "aa1e2adda4c30d106342d885ae9ae5d18dd5dfb084d7ce5696157a77711ba0c5"
