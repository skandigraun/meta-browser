# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0072fe794f8f9efa7a144b0343c818c"
SRC_URI[sha256sum] = "429db0a1ace114ae522d518de05e62161f81f9c2b96d50c52a6a669396c4c438"
