# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c05553081fe8332231f0ac98e9a472e"
SRC_URI[sha256sum] = "a9354e70566cfb3e52ce357b6c9bad3e1797f28e33bfb8cf4eaa6e887e5ba470"
