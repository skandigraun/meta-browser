# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c87a3e98de123536294f23d84b2825a5"
SRC_URI[sha256sum] = "9f90eb87dfeb6f0e8908adaf8e9df1e63164f977f10c80056b3f63c598c58b75"
