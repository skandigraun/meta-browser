# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a97afb2778ea39b3232b4808ca08a677"
SRC_URI[sha256sum] = "870e77a33aab6e1a5615710e7f4a04e82f3153e7e0b4cb9830798d20fab4a2e5"
