# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "969bf2712bb6bcf9700e62f3a42d05d8"
SRC_URI[sha256sum] = "5bcd506e681d383250b07d6924d63c9298b56ad67cd29b42dbc6323ffa95c2a2"
