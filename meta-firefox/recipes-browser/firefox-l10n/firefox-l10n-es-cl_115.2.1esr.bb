# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bfe98610cc7eddd95f6e1940c7618e4"
SRC_URI[sha256sum] = "336128520b71af88794604e5fff33b7ac2e1f2ee9b34c10562cda9d016f5981f"
