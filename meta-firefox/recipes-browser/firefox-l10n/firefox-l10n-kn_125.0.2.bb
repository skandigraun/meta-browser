# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "241b38e61f3e6c77f590fb88a91cb61e"
SRC_URI[sha256sum] = "0fdda65a08c65a3ffcd0e34f6f0582eedb9f8f16240230c67605060e6ad3806f"
