# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75a144df4ee9a195473316d12be04999"
SRC_URI[sha256sum] = "71a81305581ad9a7efb8810ef4757bd6b39edffcea108a966547ebfff79c0533"
