# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4438d3b248a8f762dbab7d1d60569b4"
SRC_URI[sha256sum] = "b23c1e00bc2eca09bc93f758e75d957122f1e1bc04d1502dd136ed819f3c580d"
