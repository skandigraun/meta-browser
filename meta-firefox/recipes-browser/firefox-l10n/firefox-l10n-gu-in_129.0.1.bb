# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e317abcb90ebabc539962eafe3b34b4"
SRC_URI[sha256sum] = "10b82d68967f2ef2cef781e1d4ccb8743e1f003c76ed87d837b0b990d62d12a1"
