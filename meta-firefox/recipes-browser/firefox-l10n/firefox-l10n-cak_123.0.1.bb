# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3049e95cba1e55c9e105475ab9b26b14"
SRC_URI[sha256sum] = "8e8b9a26ca94d43aa04d60a55687c5ab414bdc07c0696ba17454a6075d9d5aef"
