# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e9e5a4d462f7d5077d13e9358736561"
SRC_URI[sha256sum] = "33a07ea45b57b05cbd4e77a4fb79d0902f21f7eb1b3a9f3a3c46ab0a4ec3467f"
