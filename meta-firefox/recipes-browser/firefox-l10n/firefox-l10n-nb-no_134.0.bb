# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0b1ea83ec92ab0e072c8635dc880986"
SRC_URI[sha256sum] = "9701c1271ef388e7de3620243f6ba1dec07007d4ffebdcf47db6dcaa9fb21977"
