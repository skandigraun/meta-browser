# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1746bc86f45538a9941857453f8ae21"
SRC_URI[sha256sum] = "77de755182883f4f4c2e1992a6ef33d630e8742679911d500858c6caa3607504"
