# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14ab6beba59f4cc93725786837dc941a"
SRC_URI[sha256sum] = "97c04205c3ff13972191636b4c8b1904fadfc4a57535408f5f9c057774886e70"
