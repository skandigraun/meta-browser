# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5ac0d6eb0b1626cb350d3f7dea3393c"
SRC_URI[sha256sum] = "f7776b0824f8c87f01c2cb46525b17202ea8fa68fbd3d4d870d7d10d98eaa589"
