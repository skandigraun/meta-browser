# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d7d2fc5bdc1e02a7e87e7549a799252"
SRC_URI[sha256sum] = "07f398c25633b500700567abed0088895fda94eff0c77e69070e9d8f02e97210"
