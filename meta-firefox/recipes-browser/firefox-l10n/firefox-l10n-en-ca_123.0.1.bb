# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "939950482b39fe8fac74861572edb80f"
SRC_URI[sha256sum] = "f0f276f52a511d43f9b0fc027be4f8b80992f908bb02f2603a022d6957b6bd01"
