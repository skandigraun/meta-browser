# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "616973efc325351c12d66a98fd02669c"
SRC_URI[sha256sum] = "44965ce348ab3d2f701d0524a9809baf6056dbea9184451add1833b78a2468a4"
