# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0699e1108df0097ffdbefd97c53d1c02"
SRC_URI[sha256sum] = "739dc1748cb6e7e9932fcd3aaae99c62d3246ac3a040ea7e466ebc294af85dda"
