# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "274f702619c0703aeeaaddac7ec91c7b"
SRC_URI[sha256sum] = "409e4ff3210ca76177f6f0c75282dd883a9faa2dab5879bdd058f96ed501d345"
