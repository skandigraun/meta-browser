# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "979dc52099593d0fba9b30a1e89bfdc9"
SRC_URI[sha256sum] = "09513d6aa180f5bb71bdcca1341096814f0deae27094e0e6a1a3ecae6f24b6fb"
