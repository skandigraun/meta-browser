# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac1d3960f1b6f3ced28ab92095fb7546"
SRC_URI[sha256sum] = "1148f17b4704787f7717aad71413bb9dbc41af83797ba53258a5749217a6695e"
