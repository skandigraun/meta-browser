# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fb4064b6f37990096ce1409b5ead75a"
SRC_URI[sha256sum] = "59de63fd5045a798a25a88a3c204d8f9cbc25f19925ca8e34738fc301d3ddf63"
