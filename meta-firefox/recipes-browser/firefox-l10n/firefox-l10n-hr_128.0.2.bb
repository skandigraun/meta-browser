# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b08796c5db764072e067301361cb8e3"
SRC_URI[sha256sum] = "b267c2d28517fb4af0cfe60e857dd88a007c29c25ac6b4a7bbb9b34de5d7b3eb"
