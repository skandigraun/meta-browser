# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf65d6851a213edd739db22dd510ab25"
SRC_URI[sha256sum] = "4213154eb645ad87cdfe22f8099dfe97fb3ef4284abe6f6277a71881cc5f7b98"
