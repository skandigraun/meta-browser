# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba1f2c744895ab3ec4f77c7da7cd4cc5"
SRC_URI[sha256sum] = "959ae8a5098277d76aba9fed28e5dab1a9e12db0c0a51b0e35e010de296172c1"
