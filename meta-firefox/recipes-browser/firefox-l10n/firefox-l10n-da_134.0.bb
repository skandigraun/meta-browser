# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9c0000ffa782b8e2244a2516b21631b"
SRC_URI[sha256sum] = "5eb333505077eaf4fb771747e1f95682c9254a947fc18f651d188fc378d7ec42"
