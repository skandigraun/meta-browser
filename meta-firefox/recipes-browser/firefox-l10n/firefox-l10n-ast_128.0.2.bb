# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f58a14d41879876677ef4303df26460"
SRC_URI[sha256sum] = "cfa874d45f76287dcb09a1460219e223cd2c61bbe44b4640a40aec4b3ceeef22"
