# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "612e36598fe1741e2c6feaa2683f11b3"
SRC_URI[sha256sum] = "ab3136a1fbaf64aacf78cc1b4f8d1e6125405ad16f04752beaa9658df6d6e711"
