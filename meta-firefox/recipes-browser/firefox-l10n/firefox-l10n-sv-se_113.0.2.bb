# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1f37af35fdb94c4bbd61df640afd6f3"
SRC_URI[sha256sum] = "7159a6a2fa5816266173c68482ee904558c641c2516db74b35298ccdaadf4dad"
