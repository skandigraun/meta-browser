# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bcab6090574820ae5af997d88f74cf7"
SRC_URI[sha256sum] = "4dee98b2bd2100ef9955da5090b6e9f379c4582815ef450ed42043ccee4c70a9"
