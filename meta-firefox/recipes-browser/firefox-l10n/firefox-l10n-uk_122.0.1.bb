# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73ce4f264c47c46e27d02c55668524c1"
SRC_URI[sha256sum] = "f759500afeb3636fd5798addaac90b5f79ee11ad997cc44f40fb499db6571edf"
