# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f3c21b55b8dc03c86c7a297ec3921d4"
SRC_URI[sha256sum] = "06d135595b2c9e8887913f9514a9d3d936fba8fceaaec47e3b2e404444d878c8"
