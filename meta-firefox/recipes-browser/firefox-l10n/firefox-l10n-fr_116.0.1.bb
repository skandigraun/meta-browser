# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75e15d5894d5ae951c8f8e8f87b40197"
SRC_URI[sha256sum] = "77845332681ebaddf62dcea9b9dbdf36941a98dc3fc6a63757ae21a0958f94c3"
