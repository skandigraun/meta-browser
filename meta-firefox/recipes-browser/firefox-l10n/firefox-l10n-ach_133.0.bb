# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a80427ebc694ef0f79fc9a6c628b2a0"
SRC_URI[sha256sum] = "14cf389708a91123f862d197cfd44c31bb156d48d5cf7ee2f2aeb1b374fce241"
