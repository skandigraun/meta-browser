# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39cbae79a1acdf337266067af7b7350f"
SRC_URI[sha256sum] = "d04678bf28b9997e7e041483616de7133884b5d41c11ed52bfb7fe6ea096b0f2"
