# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5322ea94fbd319034d1d3e7d9152b5e2"
SRC_URI[sha256sum] = "1f586dcaf95c7e868abf4dc02104cc7987c6a7824bd62912c3a4c14a410dc72c"
