# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e257c1bd710a129eb9ffe919340007"
SRC_URI[sha256sum] = "6fcc9a8ed286420159253fb145dd9cbe1cf6f3664409541d572812f129b09e76"
