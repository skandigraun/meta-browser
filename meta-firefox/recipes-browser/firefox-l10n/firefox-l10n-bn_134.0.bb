# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2a0ec5b55ddc00ae536a230e4f55a28"
SRC_URI[sha256sum] = "9f7b83a2e8a18e1a55594bca6b3edd7897da97b7c38e0e036a274d79f9cae5b2"
