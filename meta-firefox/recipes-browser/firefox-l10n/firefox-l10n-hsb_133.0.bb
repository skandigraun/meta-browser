# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8284502d73621eb15762d002ede03a3"
SRC_URI[sha256sum] = "c115f863270aa77b1ec71bfe3a8067f569ef1950e6612100b84391e5a0b27c26"
