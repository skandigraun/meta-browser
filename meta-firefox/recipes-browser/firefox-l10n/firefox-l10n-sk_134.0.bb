# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1c75f3e13d64716d552dfc494b5965b"
SRC_URI[sha256sum] = "1e42e18e61aaac307630dafe50001cbac558c2f3ce243887a49fbaeea5b9de49"
