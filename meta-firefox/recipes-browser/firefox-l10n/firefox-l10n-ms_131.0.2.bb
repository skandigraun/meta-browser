# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8890ddc3472ab3ad65049cf4c96209a6"
SRC_URI[sha256sum] = "8a03feff45215eb92926c9b258381dc71b77f791a3cb1b930402c3bcfa44a267"
