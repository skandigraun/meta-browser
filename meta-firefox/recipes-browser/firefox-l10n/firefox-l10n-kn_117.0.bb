# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55942cd3283bf3cd9b52d761d82c1b36"
SRC_URI[sha256sum] = "13e7533e887e2cc2a8b1cbac2403818f440ab219192e73e0c62e455a596755cd"
