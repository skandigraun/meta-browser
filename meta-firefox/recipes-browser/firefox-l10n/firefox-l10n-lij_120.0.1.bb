# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57312daad641c11f5a9cbfc18604575d"
SRC_URI[sha256sum] = "bbffee96ad5e2753cd11ed0db4bb063675b673458c3321d670432275d5c6122d"
