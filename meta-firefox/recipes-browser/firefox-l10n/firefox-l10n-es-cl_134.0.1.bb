# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08fa6dffe4c91f1c4a52cc491177b686"
SRC_URI[sha256sum] = "a967784f865734a1cf7df1b484bba18f7e674c4dcbd689e708d66a8815a06838"
