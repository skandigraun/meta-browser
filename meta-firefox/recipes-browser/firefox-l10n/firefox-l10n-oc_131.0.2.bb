# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adea631ed993d3ed8dd37afa83635663"
SRC_URI[sha256sum] = "3720d4d8e7453d448004d7690c394bbddbd1cbbf305adfd7ed4e89ac01cd6355"
