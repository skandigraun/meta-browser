# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fc9abd2b17161664c545a4a4059fbf0"
SRC_URI[sha256sum] = "4d80c473d55d55c5bf34c89d656419de8ed7cd4288d16496b4cb5695dbe519c9"
