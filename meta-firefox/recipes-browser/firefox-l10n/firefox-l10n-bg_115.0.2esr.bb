# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe5b777cecdd87aa0154932563fd11eb"
SRC_URI[sha256sum] = "386f10c49468c6b57724596335ce1adec27249eef442291673946b68056d4668"
