# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c11dbe13e6d3a66cc14d97ecee6b3ff5"
SRC_URI[sha256sum] = "01220cf35f7c3afe7165866ffabf157e12ffd2ce06b9e8ca052d18ef460205ca"
