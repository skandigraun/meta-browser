# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ed2139f9fcdb29bd112096a959ca2b1"
SRC_URI[sha256sum] = "3ba189251ccec37ca3b876365982a4639773f74e792e39a6809f9fd8a927029a"
