# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abdeefadc46512acee989a953c0662c3"
SRC_URI[sha256sum] = "2213d81b01edc40166c729565fbc5794e36f937729833ab87d59b3eb545b0c36"
