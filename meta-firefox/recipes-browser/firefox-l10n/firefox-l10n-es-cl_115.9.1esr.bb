# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65b6bab7b697732995d8bddf3b63a417"
SRC_URI[sha256sum] = "889784e6629f2cd2a1c6abcaec05fcad9b4099f24a7737aacbbc07f10889d04a"
