# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d26f1e1d6c438a7f04b19f1aa4028a4"
SRC_URI[sha256sum] = "782a9ca5b55ecc1e09f1babb098ebac58ab17dc975ea69ca394ca05df1d02154"
