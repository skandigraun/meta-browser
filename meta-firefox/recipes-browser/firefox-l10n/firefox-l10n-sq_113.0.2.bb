# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9004e9ef05626785be4c8a6454a3519"
SRC_URI[sha256sum] = "550de125a38de4c82c46a726a19348535835b5954d8cff052cdca83d19a76275"
