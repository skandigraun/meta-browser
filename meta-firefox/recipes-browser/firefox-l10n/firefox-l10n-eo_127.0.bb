# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acc0b26ec3491d382a81f630a36dc973"
SRC_URI[sha256sum] = "9c8cd8a0cce29a189f92b7c93230c8c0b4e43eff6d32c3c45e3ac7ab62f4e70b"
