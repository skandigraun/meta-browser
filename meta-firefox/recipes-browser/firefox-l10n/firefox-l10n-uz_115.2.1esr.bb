# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "800df3d74601838301a933a04ce41d95"
SRC_URI[sha256sum] = "05feaade7eb1720b9fd8585178739f6d605514df741d1aae9133a19de70678fc"
