# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "897b1ef062012938753bb0f50b1762df"
SRC_URI[sha256sum] = "44bc2f9a6188f634308fdc95d9c14563d4b51561f2166b51d8f9a9cbbc53d3e9"
