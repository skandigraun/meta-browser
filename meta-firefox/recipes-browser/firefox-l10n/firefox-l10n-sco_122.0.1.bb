# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c87f2f11bec8d35a0100af065796ba0c"
SRC_URI[sha256sum] = "054c7bb351131565b3fe5dbb68aaa3f55b6d9d06619fd56be7c8c17024dd2303"
