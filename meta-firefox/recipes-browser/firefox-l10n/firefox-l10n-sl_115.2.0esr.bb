# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b381ad14b4a71a2835a46ea7c5c2a208"
SRC_URI[sha256sum] = "74d4f90b001f465b816aa43f26060db5d27e57412ae1208392483b5a487d86fa"
