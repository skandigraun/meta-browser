# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ff2114815b8bf76ed287634d38c750a"
SRC_URI[sha256sum] = "94ba26fe605fc22e355df6a9f3c64252d5ab647b5e8f740e744d7550eefa27c9"
