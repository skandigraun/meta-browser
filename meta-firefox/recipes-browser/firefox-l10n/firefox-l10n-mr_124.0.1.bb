# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc0f90a0a12d4d19c7e9fcf228f96826"
SRC_URI[sha256sum] = "008226fea586c3eb6d10f8e4a5f59cab6fc7b54b85166c33fc802f0fc7798b13"
