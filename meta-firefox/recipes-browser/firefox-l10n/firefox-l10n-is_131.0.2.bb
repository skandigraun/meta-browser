# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "057771251ef3d841975952dca9e54cd0"
SRC_URI[sha256sum] = "4d2dbd62bce70c137fe2e1a6151b44d0655a8edef3bfafa02d052bcb3872b2ca"
