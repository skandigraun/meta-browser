# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45bb07a5cdbe53402c0cf7cb620b49ed"
SRC_URI[sha256sum] = "0c0dfe47ba586fdcc9cdaef828ece0e5cac993071102d8fb4a08eeb512d1bad7"
