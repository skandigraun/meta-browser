# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f1737ca731141f4d962abbce2db5b30"
SRC_URI[sha256sum] = "c2f121d8e6b73f1b35cfcf40198b18a38d188ecce5324920ad15545b5f40c42f"
