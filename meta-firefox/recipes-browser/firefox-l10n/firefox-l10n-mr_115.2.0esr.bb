# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04526e639605d47de1d0d1832df40ad7"
SRC_URI[sha256sum] = "b941228b6351d88812f6f5e299ac3f3df29df9ea2875f6ee1cb2837eb1c48099"
