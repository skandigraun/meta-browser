# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1b611bd59b358bd962ae085e2b71531"
SRC_URI[sha256sum] = "6b12b391a6310bcdc1c6f9079b4b059b8e3198b6393b5c6da53c0ebec23a1d0d"
