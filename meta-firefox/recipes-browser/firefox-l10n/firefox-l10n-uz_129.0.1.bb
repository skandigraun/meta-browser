# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88fe13093c5d62e0cd2d1622bea509b5"
SRC_URI[sha256sum] = "c6a7b7c8224939f56676b73adf9adb9274261e7766017bd9e73228886df64561"
