# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1652c377fefa3fefc50c8254eb2e5f"
SRC_URI[sha256sum] = "f70f1ff55190f78152ab015db0fd92fe8f532ec49e07aac483ce9cfe75cbaab1"
