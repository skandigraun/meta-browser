# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b95eb5af1a20e1a2a19beff537e6142d"
SRC_URI[sha256sum] = "ce09287306b947782d2723c58302f3a6db50990325b947934edc7a9b1a7a92ba"
