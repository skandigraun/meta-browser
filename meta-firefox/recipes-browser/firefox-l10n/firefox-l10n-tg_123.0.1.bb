# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7650b4230ad56e9ff71da28d7a4052fd"
SRC_URI[sha256sum] = "55f3db9184cc765b97b85eb7dbf583bc3bd11537dd7b65d7efbc15b458cb10d5"
