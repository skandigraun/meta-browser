# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a51a3b1ef7b41c040ff4e311acd6be51"
SRC_URI[sha256sum] = "e5a352836086cc8e14b98dd0f8a3bdb048541fa1adf088d6a751160b78540947"
