# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71b91b5892c953826a2fb93f28c6268"
SRC_URI[sha256sum] = "4d3030fb518c353b60b458fa286ee5649765c61807462de708a3837c87f7f8d0"
