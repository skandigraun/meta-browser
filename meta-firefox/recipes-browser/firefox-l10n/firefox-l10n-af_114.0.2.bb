# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d459c562af41cdfe849cba052fb1667f"
SRC_URI[sha256sum] = "a09466ef9f0c5ce79aea28bdab85cc644196c055e8e1b969c1ccd37438430d61"
