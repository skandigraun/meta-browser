# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46a8e80f0726a382d7935a167fe49a3d"
SRC_URI[sha256sum] = "c991f568302082b97d73dfbecc161912ee701fe936d2f8d5f3fd5eefbc6e253d"
