# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "517eecb8475bd38a24f729bbac6d3b4e"
SRC_URI[sha256sum] = "bfb30d66ccfa93734a55197967ad2819bef8a3e6aaae392d5b5cfb01c22c0876"
