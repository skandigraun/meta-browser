# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22b949821271656c8af2325d1f21b528"
SRC_URI[sha256sum] = "01df2d612382bcd75dc5fc029f75b96584ad688824499a64815414665e635dd7"
