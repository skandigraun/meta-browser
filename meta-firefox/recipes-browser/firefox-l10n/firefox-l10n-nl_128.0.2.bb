# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eca4671223c9650a33dd15a2404e664"
SRC_URI[sha256sum] = "5c1e628775752b3fb93722b639f16c78454ba56d917d2baa344be65962fe0edb"
