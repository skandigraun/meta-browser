# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32a83d6ff6bece0cc44581cc28b35a9d"
SRC_URI[sha256sum] = "d24070e36a2432e03260ca5cb88b5a552a84a90686f87855cd5b53e447918ad2"
