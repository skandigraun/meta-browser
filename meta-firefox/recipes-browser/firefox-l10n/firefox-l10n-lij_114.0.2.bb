# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25072820e0e34691ace6799a7f24bfa1"
SRC_URI[sha256sum] = "94ca68782cba4b73be3820bc9c61193f6ad8b5769a81ff17b6edf69a0d3f7b10"
