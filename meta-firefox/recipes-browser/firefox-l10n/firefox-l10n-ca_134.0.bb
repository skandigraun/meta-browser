# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c28eaf2ba77fcabc0b420fc7d35acec"
SRC_URI[sha256sum] = "17dfc0b1f554b80138661c1852f905bb5d71ced8282994896469f833bec5ebcc"
