# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa256fa231ff9149561cfc0362748f0a"
SRC_URI[sha256sum] = "61738a7365be95eec4eba9756531052a8e606d457f1ca597b25347114bcd4a8b"
