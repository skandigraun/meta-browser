# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0177fbcb9d1d96357aea11559984df8"
SRC_URI[sha256sum] = "ad47f074a647294b3ae2f1fbd5240a817f1dd69a116ccf2f51f62796d139bb1c"
