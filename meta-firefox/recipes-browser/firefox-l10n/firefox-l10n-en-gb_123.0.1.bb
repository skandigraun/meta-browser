# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7206c8c0298151cbc2ed3ea6860952cd"
SRC_URI[sha256sum] = "5df99e149b41dde5462bfd2ebb4114588d1063ff792cea76e48ede43f74c14e8"
