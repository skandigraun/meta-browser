# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c781e1ea831797ff5990388ad406dce"
SRC_URI[sha256sum] = "9cfefafd8270cd2a644e45950f85fa9bed4ef6ede74e518143d8286237682596"
