# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a84bef7062dde3a1a013412e697154bc"
SRC_URI[sha256sum] = "484274d4ef6d1267bae26e9793d143f343b6d51fcdcbc1f1116ab0a6924dad10"
