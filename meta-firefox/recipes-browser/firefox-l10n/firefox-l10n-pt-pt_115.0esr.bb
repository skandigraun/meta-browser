# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dfe940cb07272c190f90f8af4479703"
SRC_URI[sha256sum] = "e816754bdd88369efa5cc9d43bccd5025e35735a8b25ec4809d4d698de599f39"
