# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "600306a07e5a944247edf646afe9bc4f"
SRC_URI[sha256sum] = "15d56a612705db8dec4a648dd3db8fc7d6a86aadde387b740188eea2548d2524"
