# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d941d3fd7b5786396e66cb4c3e8160c"
SRC_URI[sha256sum] = "69dfdc4c16c2498cf59e602b31d9c33c4b35509f8794d7997d879c83323fd35e"
