# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4de20d1f22028e64e1b552fe272d0e87"
SRC_URI[sha256sum] = "76aa93a0965277b9862f02fb50c32c8a577bd67f6c31c806f379fe7897d22e92"
