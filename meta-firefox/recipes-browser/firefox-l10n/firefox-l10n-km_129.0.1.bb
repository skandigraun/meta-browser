# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b528a8a6fd7c78d78c9e745e33e716f0"
SRC_URI[sha256sum] = "f8e9a192f3c086c3666ea3bd9fd7d651d533206e728cef6496d1e404072a1d2e"
