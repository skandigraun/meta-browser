# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf6bc26966870565c6ce1bc609789650"
SRC_URI[sha256sum] = "825410ee4860f3466803725a7a604530b5641779f819f48e3fd47b5831a47659"
