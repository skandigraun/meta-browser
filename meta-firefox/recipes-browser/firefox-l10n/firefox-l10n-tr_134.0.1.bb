# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f60fde18d9dfef72296a660ad07fb1ad"
SRC_URI[sha256sum] = "a544e9b7979f710f051df547c1299c5dcfeb1696d9c6d863629e0bb989c31619"
