# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "767f94988d10fd655e742cd2b9fd1e19"
SRC_URI[sha256sum] = "542784327b06625f276d8bb4d6dd3e23beffddb15b5b5b57ff309588ee6085df"
