# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef5d61e932e5d25e6a63342a568a2ef8"
SRC_URI[sha256sum] = "b2e9a15d099ca186e44002f57fea86bbf60038fb3e693ccdca32c1bfa83d5e76"
