# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ddf8185920735d572b9caee629ef2db"
SRC_URI[sha256sum] = "abc9aded56de544c917deb9502ca76b5aad9f72d444e6462c9da37588ab4c33e"
