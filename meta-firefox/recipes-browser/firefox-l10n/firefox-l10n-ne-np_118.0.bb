# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "744c85a061aa36395ec92af49827f1c2"
SRC_URI[sha256sum] = "6a977c8ab9fc9328a6cdde0965d7669aa602fa0cc1f26e4ae0b4e548e8258e95"
