# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cde21788da3bf350e791e0c04820a0c"
SRC_URI[sha256sum] = "50e9bec7a9d8ed8c23be40b6e023ca33a6c2849eb75de5bd0cc856a3e0b23c17"
