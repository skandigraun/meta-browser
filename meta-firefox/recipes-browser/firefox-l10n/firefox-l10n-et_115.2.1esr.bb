# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2614ff34921f6c1f8a34d3566848871d"
SRC_URI[sha256sum] = "cad3e3a1668001f2a5e54c91ed6874500530bb30866577c5283b49f344fff787"
