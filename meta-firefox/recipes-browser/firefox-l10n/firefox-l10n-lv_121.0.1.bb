# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bba59fec5afc2d0902e372b94e5f7977"
SRC_URI[sha256sum] = "4909951a617bae56b8c7ae2e41ac7c8f8368169a5909376f6fdecb92997e973b"
