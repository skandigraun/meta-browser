# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f9072f7a535bf1eb8b4fc8c16d1e1a9"
SRC_URI[sha256sum] = "29d0c1ab5e06ce9fa89e9d34bfc7ffdeb97f913d4270ce355399ff241f815ff1"
