# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91feee5383e576b00d77feff991f272a"
SRC_URI[sha256sum] = "547996b04d4a859a6a18c2c7867108f70ebed0d36985dc3ba6c43dbd4dee3295"
