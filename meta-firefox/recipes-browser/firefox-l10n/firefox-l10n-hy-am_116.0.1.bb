# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "607f88dcb007bb4642224b3d92d2c3b0"
SRC_URI[sha256sum] = "27bb049149646f762d28d97c6f7e04f4591bd374e47055df1170ac5b6b025606"
