# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4641ca758540061cafb68f1206f6fab7"
SRC_URI[sha256sum] = "66ab273df2efe1c43ab65d6d9d4e845b6a45ea31ac50e5ec8a34cf67b26faef0"
