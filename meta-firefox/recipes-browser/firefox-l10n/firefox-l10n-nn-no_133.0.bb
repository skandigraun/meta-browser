# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2bfbf3c9fd2788f7c42cf47e1ba5f8a"
SRC_URI[sha256sum] = "4a244776d8268373d77298659fc37a5cdcb34953415b6e228f139fd5b0950211"
