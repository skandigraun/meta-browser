# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "259960e7a109da997984d16e6b2b04f8"
SRC_URI[sha256sum] = "7e077c0b81df9a0dcfc84646bc42c4eda60fb260e826f13dd5b521fadccbb108"
