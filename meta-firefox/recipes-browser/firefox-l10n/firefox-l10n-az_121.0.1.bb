# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "428ffcf69aaff57a77f3ca48b1b80d2f"
SRC_URI[sha256sum] = "7343aa7c9c939f691b2e7f2d42fcff73c55bda392bac9de0e7edd81066d8e44b"
