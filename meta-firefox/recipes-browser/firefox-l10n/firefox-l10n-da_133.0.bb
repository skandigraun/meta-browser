# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7eed610cc8023c8e53d161f9502f8b3a"
SRC_URI[sha256sum] = "5e2bc11ff4d76f56e210f637e34fe27e530d8b54dde5d47982fdbc871ed7dc74"
