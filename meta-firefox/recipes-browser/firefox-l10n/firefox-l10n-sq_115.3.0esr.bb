# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af3cf15e546cacd677b796b1130ac502"
SRC_URI[sha256sum] = "2b8e8dd5f0a7d1ba2012eaf256741077234ec3306a31c1b6d3e4a23298b0f1c7"
