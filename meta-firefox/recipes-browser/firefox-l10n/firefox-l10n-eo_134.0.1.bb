# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fdef309bfc1c9ad51d959700d2a32dd"
SRC_URI[sha256sum] = "4d60d46cdb3a8d54474bda16f28b4bb002181d70ac51bb4e60d547019f9d83bc"
