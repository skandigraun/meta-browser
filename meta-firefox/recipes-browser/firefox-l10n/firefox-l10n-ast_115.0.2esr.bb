# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb123f57013c604ed36c49f5924beb00"
SRC_URI[sha256sum] = "01181ec50d59cd45096164598dd0ba42296aa98017ce1f7c445802f3e5e04f78"
