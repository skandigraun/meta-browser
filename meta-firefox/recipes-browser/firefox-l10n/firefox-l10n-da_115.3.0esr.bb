# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7aeec8c1d172bfb5cf631427a00464"
SRC_URI[sha256sum] = "8e2ddb3606d98bd7560e457a35c7e6e3be4bd8a3308e41341c9ded8ed4daf3eb"
