# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b353a7288f06877d46dcb2b8ec80836"
SRC_URI[sha256sum] = "431b4fdec82a0aeb57a6b211f058e8b9ebf2faa7f65021e7229d9ea77b48c160"
