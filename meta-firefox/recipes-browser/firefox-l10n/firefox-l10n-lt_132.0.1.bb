# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "513c28dea10c99789af41868f5ec834f"
SRC_URI[sha256sum] = "93bcd893f25d8ef248d6652435896b287e286accb73353e17899aa10a0a7c03e"
