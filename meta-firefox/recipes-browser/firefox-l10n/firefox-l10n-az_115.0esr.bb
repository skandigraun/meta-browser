# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1882aaa6336c6adbcd0da61ab83b49eb"
SRC_URI[sha256sum] = "6461677182bca0a92d8892c07383778c05c21e369401e65ef87e8403e2b3ba02"
