# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a65f9fbe9af023c5b4ebb00b2f8a7217"
SRC_URI[sha256sum] = "351aaee48724ab6ef74d6ce16a20f94ca35d1abcf75c4f0b4b13b339019263e9"
