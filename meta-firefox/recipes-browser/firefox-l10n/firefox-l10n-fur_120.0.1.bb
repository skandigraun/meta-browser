# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a57d27af857c5a534b77793d9655889e"
SRC_URI[sha256sum] = "3af5a80e48c3003a15c87f14635843efb3f6d7e4b6826c4a5605a197534cc420"
