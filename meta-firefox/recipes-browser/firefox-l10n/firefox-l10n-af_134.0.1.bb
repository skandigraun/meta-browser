# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "273a1b1d7a49bccb3ce805599a80135a"
SRC_URI[sha256sum] = "dd70c19e274187bd0927e852e17a0e2876ea0b00d0d325431745152c10cc7272"
