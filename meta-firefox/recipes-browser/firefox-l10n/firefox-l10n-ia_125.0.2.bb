# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63435faa9b74cf51a2d0898c1410f91e"
SRC_URI[sha256sum] = "3681ec7c2e8347036814f2ad408edddb3aff6dfc656419064906947b155b0b3d"
