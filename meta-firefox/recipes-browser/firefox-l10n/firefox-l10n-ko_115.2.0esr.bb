# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7e4190c9bc99ba3232572fa53fab618"
SRC_URI[sha256sum] = "f4649efe63b51d9b4ced919f8f276d57d7011d7825bf15b84c8d7a2894c4b126"
