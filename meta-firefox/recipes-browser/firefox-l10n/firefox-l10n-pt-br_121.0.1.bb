# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c2b1975b32ab3f2e64f02262467a9e1"
SRC_URI[sha256sum] = "2d519b68135a9897a4bbd1e32ba126b8adb68cda42712cf65efb060ee061a4bc"
