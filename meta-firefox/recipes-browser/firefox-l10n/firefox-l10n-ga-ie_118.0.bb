# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8907fada8bf2a8440aa04787ed917ced"
SRC_URI[sha256sum] = "99fddb40239c7a43f2a1ce88edbd5d8409872db6e7d2f884138d9c8b1ee27c58"
