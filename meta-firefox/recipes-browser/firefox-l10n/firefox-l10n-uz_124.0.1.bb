# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93103f7587c82e2f8b3100d641f92583"
SRC_URI[sha256sum] = "f77fa1eadc10aff13e8a4ba97f299a9242a881c952239187364084107c16d3f3"
