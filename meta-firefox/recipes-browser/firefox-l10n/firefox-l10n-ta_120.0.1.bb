# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5398bd4fc69ddfc4b9a7d8dadc683ef0"
SRC_URI[sha256sum] = "aa7d6b37266a62f44ac1ad6f387c8c84ddad18f7029a6d431068ea5c7f99df5e"
