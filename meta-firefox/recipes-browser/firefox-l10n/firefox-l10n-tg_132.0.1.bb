# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c6bc7609b8f6df5d963ed7bc8414584"
SRC_URI[sha256sum] = "7e5f861656e170fb0fe7322ad413b05d575903766c361c6704d78029473bdd98"
