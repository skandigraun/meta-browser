# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34909ccfb27f70419334055db8a90ad4"
SRC_URI[sha256sum] = "e2419ea7cccb36c4401fd69c96459212136c8006f7a817c8a157bd2c5e42678d"
