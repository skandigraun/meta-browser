# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12e40f3b26ffe29e4bb98c302bf6ff0d"
SRC_URI[sha256sum] = "d6734eb6e954e10c6d40aa8f7b3c9554ff372f03504938a3b30b174d1ccb40ae"
