# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ba526d056a9345a665b7983cecf0bd5"
SRC_URI[sha256sum] = "baa1db947af1fd98166b81654c06aa1714b774ad04c9a6a34b4fde7c4f49c54f"
