# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8ef3bce9e5e9ffee450aa7d3a3b90a1"
SRC_URI[sha256sum] = "357480adadc786e7233ef38bd06cd6cfabebbda450f8de23a63a290ea0c67b55"
