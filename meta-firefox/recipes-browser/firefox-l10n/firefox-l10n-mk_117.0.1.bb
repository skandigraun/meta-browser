# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4014b558bf827a08edfb3959d1308e1a"
SRC_URI[sha256sum] = "190ca4fd17f8d763ed34816ac9abedab7a08b29d0b63213df1fd370c0b0e3eb7"
