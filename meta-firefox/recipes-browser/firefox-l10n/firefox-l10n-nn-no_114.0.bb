# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c28fac614b5fd5e5d34ea5f197fcc725"
SRC_URI[sha256sum] = "050b33dba495f812910ee3a53affd7eae61ce2456b148a33e1883e06c6beb73e"
