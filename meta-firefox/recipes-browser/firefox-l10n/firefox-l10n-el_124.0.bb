# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cc3f7828617ab4f48e97b7e08b7dc08"
SRC_URI[sha256sum] = "94a66f8ae160223bccde85f9a91ea8c7b092bb329c86bd5902fb947982366027"
