# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfa0e16681d010f2949d9b4c16b46880"
SRC_URI[sha256sum] = "e5f65fe3a44e742efdc37a585e051f65b4d3c596e95be544c47400ba608bc8ec"
