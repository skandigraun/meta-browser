# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd9911920dc93c730f35bd3301c2fcf1"
SRC_URI[sha256sum] = "979b362f9c7cdb4195a654f19862561994fbfbd5c4cd46128e385d42fe876521"
