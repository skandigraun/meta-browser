# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0541079cd76f99231e92f80674ffc251"
SRC_URI[sha256sum] = "3e02c13156f87af7a25e826f8f72487004c3b64675be73e53eaa55f45a4b0147"
