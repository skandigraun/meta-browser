# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15d13b15086c8d7b7eac37cacb2be989"
SRC_URI[sha256sum] = "4ae46b2059e29fc5dac606276f855eaa5943cb3ec9312949b9a12284b4f47da1"
