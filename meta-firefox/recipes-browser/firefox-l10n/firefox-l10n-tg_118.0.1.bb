# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09a65452bc2d55e2c0b05911e0c6769b"
SRC_URI[sha256sum] = "c4786a6bb8ba9920014013003ffb16b5b2efb856510946920fc1b8d430c5fa7e"
