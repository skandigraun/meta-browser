# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4c761cecb7dfdb861e2bf408e508188"
SRC_URI[sha256sum] = "d631f31df431c13c6c6685efa423293a0b554b463e6b9f197295dc7cab4abbfd"
