# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "357651161421c6123ddc887966102ea7"
SRC_URI[sha256sum] = "ccb5caf8a2cf52bb8136fe2f0af32ce9f07ba734b7e5e5ea2b6af71daaa4767d"
