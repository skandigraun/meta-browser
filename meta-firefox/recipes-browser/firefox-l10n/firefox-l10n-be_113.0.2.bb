# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa7ad745b6b285acb1fa35bbdafb5137"
SRC_URI[sha256sum] = "01cf383b4d6536274accb20d24f348ea100c692977f63d744d74af03f4fab779"
