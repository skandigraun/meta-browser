# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdcabeeb247351d2c551afcaa82f432e"
SRC_URI[sha256sum] = "ce641349d703402b32f04bb5750d73e8a528abad7c1d0a2ecd101b95aad1642a"
