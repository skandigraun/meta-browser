# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b21a35d4a33fd529c2aa958c3ed4d4a"
SRC_URI[sha256sum] = "fdbac09d753b143a2fac153c31a3de3ebf2d34026e34e3cd90dd9ea76636f201"
