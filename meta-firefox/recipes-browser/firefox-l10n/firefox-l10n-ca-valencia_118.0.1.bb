# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d752627d04f68a11d53775d4c47491c"
SRC_URI[sha256sum] = "d2d06999dbcc4b6a7e22e02a65e06f04587e5f5d53ce7ec8d76d1212f5aa593a"
