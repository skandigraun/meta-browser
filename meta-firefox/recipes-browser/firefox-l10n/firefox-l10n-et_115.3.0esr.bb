# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37eafe3dc1917163e74e206b9adb20fd"
SRC_URI[sha256sum] = "a9c2b385c70ab52070d3281cfa688833c271b2e3f477f085516192487f0d6045"
