# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df2794e49c63e9aeea680c45ebfffa96"
SRC_URI[sha256sum] = "17c63f91d17ab21ca4880929630199c4c7742a963cd226014f14be95e7a1f434"
