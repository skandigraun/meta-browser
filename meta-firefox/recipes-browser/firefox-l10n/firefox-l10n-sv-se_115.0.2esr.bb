# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a95823d1c06455198bcb32631c76e125"
SRC_URI[sha256sum] = "05813b39cc65c1a0061c310a857e285c4393781bea8d04c080a5051025be966b"
