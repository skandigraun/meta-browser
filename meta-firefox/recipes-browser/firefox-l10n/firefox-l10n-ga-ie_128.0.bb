# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59e5f5ae847514f6c46189d33343750a"
SRC_URI[sha256sum] = "5fdd1540601d74c2225863f10fd9df6bc272c902d721fc26692af038567693d4"
