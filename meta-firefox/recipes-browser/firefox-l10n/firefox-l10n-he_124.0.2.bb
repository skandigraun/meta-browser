# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ea48369d287eb354f9060e91d5c2526"
SRC_URI[sha256sum] = "a95f53d6f56fb570e58fa7c3014d0fbbd9d742585ad7cc42be19ac6c326b8f7d"
