# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ae5c34a33fc5ef262480afa356b14de"
SRC_URI[sha256sum] = "4930a2c5472e7c107b69870deb37757cbeff82e98e637091f2cb783bec5f4530"
