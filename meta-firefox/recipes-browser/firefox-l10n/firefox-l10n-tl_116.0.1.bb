# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c356acf6ad64e331bb70a683afbad043"
SRC_URI[sha256sum] = "35bc3382b2b96401fbc993926106320059c915368d7e6cc50503b1ed548455f8"
