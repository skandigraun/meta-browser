# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ed40d045a27a81c396193f59e300ba9"
SRC_URI[sha256sum] = "e74bc479bf34dbeed872a23a8673770c2d15d4bc5d09de261a572025221d828b"
