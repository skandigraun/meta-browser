# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d57b7e9e8c97ae1a4103344bddc95e3"
SRC_URI[sha256sum] = "e6d6c6bcf0af42e482c103866dccd34739959ea8ff0df548327c7f0dbcde0539"
