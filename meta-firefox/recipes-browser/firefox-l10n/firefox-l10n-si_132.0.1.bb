# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd318650aaa344e088668d44b04d1838"
SRC_URI[sha256sum] = "0293201d8786e58901ab84e512c2b49981af6839322569f7367b07f774768c32"
