# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fea8c8a5ab4e15c3b7966a8d574e81ef"
SRC_URI[sha256sum] = "7a380a91dc8dd8172929033719f6699b60bdaf5acff5b728013f0f983dfd596e"
