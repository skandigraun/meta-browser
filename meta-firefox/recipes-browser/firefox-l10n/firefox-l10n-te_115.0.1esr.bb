# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3f09004c64fe6b5f30002cda7f3bf50"
SRC_URI[sha256sum] = "e83075f380c37198cd82f66e6992df8f30a6e2b1b8f69675854d93029f7e7f0e"
