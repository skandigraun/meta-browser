# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2661a171902e0d13baae12341d07807"
SRC_URI[sha256sum] = "d45bb3615c5a8880cb10d76bfd2f554a8792ad97b1fcd8909bd774a0cfb63a19"
