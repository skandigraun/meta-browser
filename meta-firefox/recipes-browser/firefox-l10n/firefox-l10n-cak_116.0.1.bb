# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052e1db8bd66a83240b9c271407a4946"
SRC_URI[sha256sum] = "5d54bd04bffa81db7c2557b78a3d50cc9b2b7b5056c77477581221ee49850562"
