# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65fcb871a36bf1e30f41a935bc03ccef"
SRC_URI[sha256sum] = "4c21bb7117b8b0e290a217e74193fb224b0fbdb871903671dcf655ffd3dd569e"
