# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e491acc3d04080b118306681f25463c"
SRC_URI[sha256sum] = "664b1346c701e5b672632429f5997aedd0bf715b4c844af6fe29d5713c13c12e"
