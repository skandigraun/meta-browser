# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11b20d9034a2cceacbf1527aca18b2fa"
SRC_URI[sha256sum] = "23b6afce461f4e0afe3365ffab47c1edc629f2356b3f4f29b931df07c8512694"
