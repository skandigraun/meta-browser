# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49513a844c7a9d66fc43e11149d7caa3"
SRC_URI[sha256sum] = "8e999e9e80d9236dede8d1fac2bef6ae03f1dbb83c24ca779121b7c431fbf429"
