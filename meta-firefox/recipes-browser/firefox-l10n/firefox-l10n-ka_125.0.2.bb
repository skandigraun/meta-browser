# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29e903d0ce9a3037655e562e3a3be000"
SRC_URI[sha256sum] = "fbecd8d5e598bd2a34046e4496c687b8838cb169d33e697b3a1da39bbea111c5"
