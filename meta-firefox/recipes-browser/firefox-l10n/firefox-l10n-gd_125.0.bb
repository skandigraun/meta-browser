# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "397e4063e2e342f41ebf7ab2eb59e811"
SRC_URI[sha256sum] = "be00236616a64efdee75b9a01da9c128336c1d8993ca9504621aba45bff172b1"
