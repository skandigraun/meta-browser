# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b79f4902aa8e2b1657098396df5818f2"
SRC_URI[sha256sum] = "87a7975123d1f762acb5ce2f57609139cd80b776d247b709c4f050dfc0686f36"
