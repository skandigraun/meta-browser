# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeb840e4a5c9e1962a4c9a5d5d3bdf00"
SRC_URI[sha256sum] = "43f132b36675de74d1c480f2eb010308eebec0ccda9006c7fe9b5167d9116362"
