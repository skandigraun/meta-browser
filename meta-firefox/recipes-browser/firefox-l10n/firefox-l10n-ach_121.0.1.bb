# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb0df586de19615257b1c487498e71c7"
SRC_URI[sha256sum] = "e0fa11cfa73bbc1957c8b389bc5e5876c3ca29cb617f0cba7092cbecf9315e08"
