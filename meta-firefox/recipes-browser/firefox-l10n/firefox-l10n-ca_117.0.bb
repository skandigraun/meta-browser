# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43de03007ef4e670e58ce6503fde9e72"
SRC_URI[sha256sum] = "5de3abed655d93810c1846007a9b261bbbc7ffe350246c47544a5966ecdda8cb"
