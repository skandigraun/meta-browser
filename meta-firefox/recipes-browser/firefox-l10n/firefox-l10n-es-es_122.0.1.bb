# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "add9780da2b80fc03153f7e4d80072a0"
SRC_URI[sha256sum] = "9d4fe1c0806e044520af1b0ca83b7076bfac89cecc1da5703d043c4dba508b46"
