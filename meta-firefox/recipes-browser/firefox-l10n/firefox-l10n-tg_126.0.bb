# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9af7825eef4b5951c406fa14c97b7fe4"
SRC_URI[sha256sum] = "26d5ed4dc3a96e266ae26ee97935a9889dbcc55d74f5751bc58131b97f170bfa"
