# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cfb0dcf7da099336a369743ad9abbd7"
SRC_URI[sha256sum] = "56a9df8f0e34c7e50e1231554a32c37fb0ea877bc15c699b9f709f23956568f3"
