# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c73fc465343611f2620bac033a79179"
SRC_URI[sha256sum] = "d6ef2b6af1a55c060bddb1422b2439aff53e4c1b2722cccbf5c77c04de1dab17"
