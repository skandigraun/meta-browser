# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bfca5d729b85e413eb87cc7f4d0895c"
SRC_URI[sha256sum] = "d5c2b119156b0bd2934048d7b3fc4a70de8598ef8c22ddfaa80174854520b3c8"
