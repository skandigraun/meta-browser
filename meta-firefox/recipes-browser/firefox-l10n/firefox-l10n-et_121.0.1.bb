# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38ccf31f3a181621a07cfeacf078c5ee"
SRC_URI[sha256sum] = "013fafd4812816d43c043aabba7103c0c30f3543124c021d87d6d8a632e40e98"
