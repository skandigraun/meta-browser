# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f49f6a2cee74645b4192b89077958eef"
SRC_URI[sha256sum] = "4f319d9debcc7eae08cd925fe82be799127099f0800339f0d958d1385cee2dcd"
