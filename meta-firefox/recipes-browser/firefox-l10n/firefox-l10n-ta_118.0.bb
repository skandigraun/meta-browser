# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0e1724185c83db412c5ffb0d61e71a5"
SRC_URI[sha256sum] = "b57f46244f6fa470e9b9d69de5c5e414e2ae009abec683fbbaf81948f021619c"
