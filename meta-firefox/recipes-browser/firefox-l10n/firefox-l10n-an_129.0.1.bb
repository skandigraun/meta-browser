# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f48b8512078bdbe5d563af6ffe31514"
SRC_URI[sha256sum] = "4e0b567fb75bb6393b478b78328766d0f381f9230e4ba3a2c27cec4f91be42e8"
