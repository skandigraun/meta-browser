# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aca702eb55c506d229574226753e598d"
SRC_URI[sha256sum] = "2d9250047ebbe15eb3fb81e22c049e4aebd13035e4795b0ad84b8dfe99d2dba3"
