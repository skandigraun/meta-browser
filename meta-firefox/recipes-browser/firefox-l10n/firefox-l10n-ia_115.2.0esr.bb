# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70f572474ad5bccfa5e685de7e934dbe"
SRC_URI[sha256sum] = "81a22d1968ff6cea9929ce0a71c85a8d2dd76b2793740250bb75995dcfc90763"
