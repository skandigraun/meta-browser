# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd4e9c5031397314fd18b76107473b5b"
SRC_URI[sha256sum] = "37c1f0eb2723c7e852ce83a6d3ea88f5c34793132b0bc188068eeb9957da6bd4"
