# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c534f2c7bfae2c1d9a0f31aaea77623"
SRC_URI[sha256sum] = "02df0da88c0dd87d0542ced138fc7646eba721bc38ffbd0c1fc871157e47d611"
