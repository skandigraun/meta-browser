# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2570a86f7ab873926be9a9c92b2f058c"
SRC_URI[sha256sum] = "3662b586e8d77bbaaf26e8a10903594b12ab812528593924c652d04bcba112c6"
