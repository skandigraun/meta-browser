# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78bc3a8d5efb9dddf09a541c922083e2"
SRC_URI[sha256sum] = "ae0545442755e6986244ef10fc073f7e11d1d2ca00f27197672c121753fef2d1"
