# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13e06e1cb065cb6e9ef8fe7c00cbe023"
SRC_URI[sha256sum] = "9336367bbafb14e282810c3e76b0142a7d5774c7c8296c9d52967a613b25cc38"
