# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7e2a0da2d7b73263e56ad5e9fed20a9"
SRC_URI[sha256sum] = "43370eaf77f2288e9c9075ea303ec0652b7f3d632d761017411bbd7be03d22c4"
