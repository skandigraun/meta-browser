# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe2aa10e6eae59796ca216fa0ae5c376"
SRC_URI[sha256sum] = "84375777564e3928b137a552354d95885d1814e2fbdccc3fa4ae1e43ee9f4b43"
