# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e410de30746d0790c13a787611c968c"
SRC_URI[sha256sum] = "af184804e0ff5620ea5414c5d40be64f69775a9c3f84b293b0398990b2a32803"
