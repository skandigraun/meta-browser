# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3e90fbedda0bac4006f071ec702b82e"
SRC_URI[sha256sum] = "723917ebaaa39ffa2644e5088e36b0d6e5a22b37f780c8e2e493d9053ab7f563"
