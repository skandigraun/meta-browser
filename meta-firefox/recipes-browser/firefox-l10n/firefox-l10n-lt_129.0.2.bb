# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bb243772a7163d460fe3a74b4b14e74"
SRC_URI[sha256sum] = "188d4f5db0a350ae33a20e1819810bc28c7e5b020f90d03bdaee5ff0300ba718"
