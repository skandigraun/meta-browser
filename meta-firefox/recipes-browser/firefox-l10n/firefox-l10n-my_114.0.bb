# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e0390d3e22b919a5d07273fb122861"
SRC_URI[sha256sum] = "ca2e41b6c29c062f40cbf8b5ebb9badfde0457350169b6ae201f607f3dc25813"
