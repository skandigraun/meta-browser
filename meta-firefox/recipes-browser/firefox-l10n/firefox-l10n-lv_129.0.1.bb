# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cd86442cc9bda633cfab985f3dd36c9"
SRC_URI[sha256sum] = "e59c84d68dff754261549cacf619778138cc595a2606de5fd2913d69430c23ef"
