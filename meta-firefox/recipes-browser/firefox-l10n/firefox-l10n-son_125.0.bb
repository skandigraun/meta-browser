# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a47569b469e8cad7dbb9eda60b3c846e"
SRC_URI[sha256sum] = "66f133a856f876baa9045c80340339ed12fe10ddab9995434b2984872796b269"
