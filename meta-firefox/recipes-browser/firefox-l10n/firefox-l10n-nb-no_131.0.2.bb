# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec073b5d0cbb18d5e627f6dcbbd0f901"
SRC_URI[sha256sum] = "9954993c833e014e0c2372932ca70a1ba62f3328d1cfcff9ddfa2b28e2a21259"
