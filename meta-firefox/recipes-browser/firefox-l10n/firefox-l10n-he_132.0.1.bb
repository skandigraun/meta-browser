# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "105ef16cfe655c4048d525208028c34e"
SRC_URI[sha256sum] = "e9fc5e258ff430717d9df3f37c8065796236b08efcd9da59968bf50492d985e6"
