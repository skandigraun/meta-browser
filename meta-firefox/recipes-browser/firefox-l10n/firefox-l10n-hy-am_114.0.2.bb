# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0569f5db70c80906adcff252d86522f5"
SRC_URI[sha256sum] = "31c25d94b60d919b697bb80e49f3e8fe8cba01598e05967da05bfaf76368a28e"
