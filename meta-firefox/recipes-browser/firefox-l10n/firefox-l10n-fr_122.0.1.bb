# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1132b917648dcb5fe1a76d87400ea5bf"
SRC_URI[sha256sum] = "90396501c501888c47c5dc8a9e0da4a0c25b61241acac59d5adfa3912f6de476"
