# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "580cf13ab38c13e5dfc1067e5bd06b93"
SRC_URI[sha256sum] = "e555195e605b8a4cca6d7db5b3f41a717eb28b62c22d735c892264385d0fceca"
