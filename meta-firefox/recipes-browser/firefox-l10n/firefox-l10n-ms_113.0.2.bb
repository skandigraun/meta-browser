# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a8efeddfcee18cbe5b63b3aea8d09de"
SRC_URI[sha256sum] = "f8a7e08b9f410f989ba198bd15cb944d5651122c9db8810ef8e2e251ae1e43b1"
