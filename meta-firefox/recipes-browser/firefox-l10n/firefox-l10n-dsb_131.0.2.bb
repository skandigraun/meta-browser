# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b24192b94a21b5ef72db5691842cb7c2"
SRC_URI[sha256sum] = "2ef0c745ad85f9341cedbaeb6f82ce3b9e7c514f14214a3a7fc3d88628b86abf"
