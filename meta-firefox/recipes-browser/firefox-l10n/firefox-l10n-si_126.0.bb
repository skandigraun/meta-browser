# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1699ece55d621b4e7891f18efe26ccdb"
SRC_URI[sha256sum] = "c6cb67379aaae573ed474b8c54512d62ecd18733778566fb281f3bbfc0be9375"
