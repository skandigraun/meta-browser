# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3199f4513ff8409a1ef1fee1f247d36"
SRC_URI[sha256sum] = "8140d1f4f517f55cfb5951e7f6e4b8f55ff05f1356d33ca2cd1ee87c9bbc6456"
