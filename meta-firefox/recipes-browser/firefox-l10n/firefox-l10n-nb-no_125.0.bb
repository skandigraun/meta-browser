# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ab2c0a1e2f8ec27b96dff345ab4045c"
SRC_URI[sha256sum] = "539b4b6a0bfd86df295c2efb35eb0d7589111289394070173db2157e663c1e44"
