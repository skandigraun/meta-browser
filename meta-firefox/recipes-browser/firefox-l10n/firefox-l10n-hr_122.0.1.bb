# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39f75f52c5dcd19a13a0fd2f56c7a760"
SRC_URI[sha256sum] = "98096a1c738aa898597d9a601f8a4cc04ad7faa329d6f9503836f0023ebb1e18"
