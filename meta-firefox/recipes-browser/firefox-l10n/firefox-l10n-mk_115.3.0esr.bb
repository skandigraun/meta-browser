# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "611324d614149931faee94a3b7ae8dc1"
SRC_URI[sha256sum] = "21db3bf355dd4bd3f564063e66fab17e8f826b000373b840a4720e0ca1ccdd85"
