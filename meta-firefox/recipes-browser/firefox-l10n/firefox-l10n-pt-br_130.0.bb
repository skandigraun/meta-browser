# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a19ec11f49db4350d9405213e0324f7b"
SRC_URI[sha256sum] = "a2f5cbf0cc58076401b2d94771c26a79257245b9b7c891ada90fc5892cf84722"
