# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d997fe8995ad6504e266fa569d2cbc2"
SRC_URI[sha256sum] = "0cf99e665c4668cb0ce7d336758605b855c0e04d0532de17f5c08ace94d3bdeb"
