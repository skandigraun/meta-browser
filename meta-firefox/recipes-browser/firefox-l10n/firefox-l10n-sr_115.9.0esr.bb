# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3bf717a53ac76ada2d78c5967c5b9e0"
SRC_URI[sha256sum] = "b3e6f264bc137a923092c086e1a1f03de037b4aa779244c2bd8cdf8b14b1ca19"
