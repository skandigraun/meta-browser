# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d87a436dd93e06047079232d6c31fb9"
SRC_URI[sha256sum] = "c466c958cc1d581164d35a49c7f4eaf68a596351ac6d1d30b310c09867f298d9"
