# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffae1c35e8166b2b836b3d9dfd4e8400"
SRC_URI[sha256sum] = "9598a48bee9b2b31c07332099582be4b586379cc5a25cc1cbf5400f98eddc035"
