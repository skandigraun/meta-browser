# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfb18a929a8772e4eda1aa6ed41dfb93"
SRC_URI[sha256sum] = "433f84f2370058342a38c2beb6c272f218214e60bcfae755c364c7a911d34a59"
