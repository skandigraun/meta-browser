# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "218e2e6b61a17b5352c8f701e0cb67e0"
SRC_URI[sha256sum] = "43a6870f2f3cd398c2484e2b05b316f1ca7d610a891c54104b34af0841d7d1ea"
