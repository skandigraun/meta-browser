# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aa086f25a50779e9d1411acd07e4dba"
SRC_URI[sha256sum] = "89f675af91bd1706dac06d4b55f0a82984c3663bb6db9217657fb50128278435"
