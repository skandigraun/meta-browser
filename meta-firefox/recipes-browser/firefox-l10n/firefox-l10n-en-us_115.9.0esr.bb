# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1265cbb98a6b4eb587d184e992d767d"
SRC_URI[sha256sum] = "0a677365e9ecf642c0a7e2ed0dd5bf38b465d3967110d8c0ef3497cdbc994c75"
