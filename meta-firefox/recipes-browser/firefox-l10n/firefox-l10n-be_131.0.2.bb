# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4857df962c2cb28023069672f83656b4"
SRC_URI[sha256sum] = "56b402664530d3606d5e0e1cba77f7d9c2591d9bc40cac8b80f7f746ea0ab108"
