# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "491045cfe7e984f54f0fac07e04962d8"
SRC_URI[sha256sum] = "d5a2df93492e485e887194f79f8f7fd6ad7628faa6e86fb41bcf341699b0ad99"
