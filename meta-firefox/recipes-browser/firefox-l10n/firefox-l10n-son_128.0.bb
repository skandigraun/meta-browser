# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d398d67496f8ec957919c95c1d47823"
SRC_URI[sha256sum] = "d8a2934548184769b59c9c0f1e9ff94f23bc8c836ba709093c8c2825836f8991"
