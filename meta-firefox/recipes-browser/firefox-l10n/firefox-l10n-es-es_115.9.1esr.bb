# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce41f97991d5a8e43dae5607efcf1bd"
SRC_URI[sha256sum] = "55cc763e8ff92448700f9f63801945158da2fcf51fa57428993c1a4a62f0b823"
