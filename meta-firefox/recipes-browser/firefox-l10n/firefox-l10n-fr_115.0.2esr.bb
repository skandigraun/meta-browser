# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c7c3d2c728b318d5be02d6925ffa2e0"
SRC_URI[sha256sum] = "2e4f63ce9f0f1d3831ad3f2241ec4e60482f54903f9f9486afd1a2f97979034e"
