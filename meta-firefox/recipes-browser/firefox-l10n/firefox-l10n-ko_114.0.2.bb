# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c0633fa7afd5375065a7cd41501a6b6"
SRC_URI[sha256sum] = "3fbd0aa4607ea5243494fd0a81555a6e863e7071c198d8005f0ba5158f34f852"
