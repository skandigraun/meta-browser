# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99f9cd48152f1b7defad6f8ca2102d66"
SRC_URI[sha256sum] = "58e859d8a20f6647e59fc361f1c5be5ad9adbc8607e868a0f0f0ff185200d034"
