# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0fdb78de54783c7018c359604b4fd3a"
SRC_URI[sha256sum] = "cff591b28e7b2fd5fb4d6233f3fcdb4214e8ead9ee2bc07c1ee2764eb5b47f71"
