# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8705a8e1601eb58d5e1e500b18e71812"
SRC_URI[sha256sum] = "9a755e7eabf00430f3e4feac89862e8c1c15255b2f9fc6fba3ff498b564d08c2"
