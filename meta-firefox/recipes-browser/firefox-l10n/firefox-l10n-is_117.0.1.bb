# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06d60d896af49ba2d6b9953585a68057"
SRC_URI[sha256sum] = "7862a8e72a1e94499f846c7e9f06c93d9a01e927e5b72f1a64d66fc4b52f4b27"
