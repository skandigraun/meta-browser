# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bee914ab992658d45df291cb76a3824e"
SRC_URI[sha256sum] = "e5492cd859c6280a1b4d02c8aa8fff981d45eab87be70854e93de77462c28ffa"
