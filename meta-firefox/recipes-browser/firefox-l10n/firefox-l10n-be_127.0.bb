# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6107a95d76a4528311bf40df8204e5b1"
SRC_URI[sha256sum] = "83667a60eee6dfdb2ce5b4a3a5d752be86329200fe1c25315be322e1d59a535f"
