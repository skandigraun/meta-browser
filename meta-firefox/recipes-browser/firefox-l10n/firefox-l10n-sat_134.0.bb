# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac50e81b623a776bef5950dc9e538f4"
SRC_URI[sha256sum] = "72336a849fa89e6cdf80555c56256d8891e2a3deccb1261528fdf2b78300517b"
