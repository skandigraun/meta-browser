# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7358896ef6c436fcc797d0dcbdd166b5"
SRC_URI[sha256sum] = "07aa91de8ce0ce566fdf34ab329cc9680da47da8c52e694a3cbcf020efd6abd0"
