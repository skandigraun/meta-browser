# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0614b589077056ec8ba7c4b43b53317"
SRC_URI[sha256sum] = "1f92c9a5354217518380255799c12137952f380afd82500a83346a1e4fddbff6"
