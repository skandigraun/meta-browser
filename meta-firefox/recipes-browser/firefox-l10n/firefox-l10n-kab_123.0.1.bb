# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed31f2dfb6e95d744b8fc94c87481207"
SRC_URI[sha256sum] = "4d4824911e83ecf5b41b516bacc56725a78c01e53b3778167dd53fa38c210104"
