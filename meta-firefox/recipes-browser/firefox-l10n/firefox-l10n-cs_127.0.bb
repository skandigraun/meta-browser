# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "465dc972ead4642f78e63181196d972c"
SRC_URI[sha256sum] = "0870fdd3fc36cca51b70cff84b8b13e16ae1b770670f80d387632c19e847b731"
