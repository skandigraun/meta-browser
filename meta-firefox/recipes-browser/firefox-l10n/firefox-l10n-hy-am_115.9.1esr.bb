# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c557056994b68fd9d2c9d7907ed40db"
SRC_URI[sha256sum] = "7438ceb09e31b9c7f78d3ff0a15b3bb69368d06f986489331959f84b908f6de9"
