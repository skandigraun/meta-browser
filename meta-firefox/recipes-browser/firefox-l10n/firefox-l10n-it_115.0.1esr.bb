# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3df1a923f475e335394677638417bc6"
SRC_URI[sha256sum] = "bfb67e3ad7b8026374d2ffefd8ea8cac4a5f88edea830b0e7980ff681bd3ce2f"
