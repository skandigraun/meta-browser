# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c8e6a9675e87881db00bbd74eebee45"
SRC_URI[sha256sum] = "85f1f5c0bddc9c5dec0164a68bc01091a106d7221467620c90e713f6a48dfbf3"
