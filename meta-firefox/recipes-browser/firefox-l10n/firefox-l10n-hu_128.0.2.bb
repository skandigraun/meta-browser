# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a5de2b1a8b40217716d4becafc5106a"
SRC_URI[sha256sum] = "fb2cd87ac523d3dcdcf91cef21ae5c3f0bcff60873927b6c8a872557e3aabf7c"
