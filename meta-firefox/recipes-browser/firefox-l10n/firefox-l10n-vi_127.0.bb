# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0d833e154ce0e22cdfe77904773d635"
SRC_URI[sha256sum] = "d450f112a74611a61c88782d5d646c2c2279aae5f8de4f80f73a5df23958e2e4"
