# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5681c2495b5cd7fd8a5fdfff6675af7b"
SRC_URI[sha256sum] = "84e6b709237385df0cf1f9c29f5d58d68b4f73b2adb56a64974c3551dbb1a1fa"
