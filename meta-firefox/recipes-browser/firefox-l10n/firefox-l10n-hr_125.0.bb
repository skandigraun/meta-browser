# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96a91c96f7b762fff789256374d74b29"
SRC_URI[sha256sum] = "39531680f489dc932c5c2e01ae477d5d84427458e60402cb2a085d674bc272d6"
