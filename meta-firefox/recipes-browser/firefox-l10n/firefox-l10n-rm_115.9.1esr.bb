# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a81d8c91f7f07c57808c53a12ea578"
SRC_URI[sha256sum] = "f43f7560933a6e6bdecd3b896f50ee082d3709189496b973dd7c1ac4ed404000"
