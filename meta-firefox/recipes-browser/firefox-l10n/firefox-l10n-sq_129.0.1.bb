# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9329ed6d7f536d473f32d656a74e1b1b"
SRC_URI[sha256sum] = "fe2b94ba9d91ef3d879617c086c8de2e53df45ddb24faba42b932c06035008ed"
