# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6208eca42860d50ef13bcc66d515d44f"
SRC_URI[sha256sum] = "16d619c02edb3179a30f7af5aea14d0c01266d46f0663b76fbcf71de29b27af8"
