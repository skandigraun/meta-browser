# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae9f11c36e99a1c2e504f44da488e750"
SRC_URI[sha256sum] = "ef006afc7eab502f2541cddedbcf47d3cfb4467de80bbfc0cefef2e1a32fd2f1"
