# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dab5cec2249c1723c95ca8ed86d3731"
SRC_URI[sha256sum] = "584e35b015414c9a5b5426af08e68fb09f35eba47c705577623a6860bef7425d"
