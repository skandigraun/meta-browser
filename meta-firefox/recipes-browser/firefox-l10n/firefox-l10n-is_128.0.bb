# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9160a954c55f50a5042c7a59ffb5d0f"
SRC_URI[sha256sum] = "86b7707b8efd7e718a6b235d6877a3f32f15df83672b1d89de2842743ad412f0"
