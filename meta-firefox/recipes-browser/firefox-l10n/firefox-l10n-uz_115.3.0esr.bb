# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d382737342b97603ef89538da9412e3e"
SRC_URI[sha256sum] = "3091fd6627537113d3345a2c4b4f67d4122c5d4a3d9c21605a0476ec2ba09fa8"
