# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec5a92e39d7d7f0fa49f7580d1d13d0b"
SRC_URI[sha256sum] = "40819ca92bff8a3869df259b9f47cc05d2ccc3b6ba5e43aa1c605e349c9deff9"
