# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e7d4f03612439b33c143b0aeaad70b2"
SRC_URI[sha256sum] = "19ebb3ff02c2e3e5afe9d1c21e10c7190c3e56b18381ac7ab3d616b3c9519ce7"
