# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fde2d979b9f98cb4831318c4b8a31078"
SRC_URI[sha256sum] = "f76fc47870e0b0b9f9c77ae7f44a32a9d2601392e43524b74e2876c99f8f6d79"
