# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "213e844c799f13d8fd5370e5839814b0"
SRC_URI[sha256sum] = "4b520a21d2ce1d439a33d46ce73a002e1e3d4e961cd542d34c040ebb94d52035"
