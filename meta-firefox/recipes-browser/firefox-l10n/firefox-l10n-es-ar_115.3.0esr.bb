# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04f0025450060f0cfa6d616127950ec5"
SRC_URI[sha256sum] = "1e20b20422a1a37bba521be203ac5d0b0c25a95b4c21fe195dabfe485d69f329"
