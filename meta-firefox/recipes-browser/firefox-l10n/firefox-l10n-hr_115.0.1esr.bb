# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a7a40b7a3d54c054ae563612540b531"
SRC_URI[sha256sum] = "30833b5aa78b80f8a9444e32ea8035df7201e752831538c0c282d62f2029d193"
