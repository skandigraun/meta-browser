# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69fcab79602ab315e402df8c958b2567"
SRC_URI[sha256sum] = "6f65d3799321a21ecebe053511e7538ebb538b8bec221ce5e8db8e5e8b7115a1"
