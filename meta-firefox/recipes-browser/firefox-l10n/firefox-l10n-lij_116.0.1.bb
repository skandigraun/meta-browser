# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc3c69d2a163f6e46a7924f7d10e4efa"
SRC_URI[sha256sum] = "8aa69d3c2d3d4f4b1997608882673349550021838dcc4a09182e0aaae817c67d"
