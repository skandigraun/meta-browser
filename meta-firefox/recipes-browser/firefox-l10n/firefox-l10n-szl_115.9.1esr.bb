# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30ae510d36c2c5821363038ab2b72418"
SRC_URI[sha256sum] = "8ad8696ebfb71a3607771641a741d2a7ef9328915b412603dd84fee001a7941c"
