# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad3242956d6a7924a7a5f735732d223a"
SRC_URI[sha256sum] = "051d7d06b7326af50ee95048f389198b165b9a9bc941d73692b2b262e7a00a06"
