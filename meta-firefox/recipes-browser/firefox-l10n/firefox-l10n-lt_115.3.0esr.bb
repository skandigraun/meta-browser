# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37c78dcb0839c5502ee4d3c54d4865ac"
SRC_URI[sha256sum] = "435e56348bede7eabfbba7808f2677e24527e48572f04fa6c3a2c281a62163bf"
