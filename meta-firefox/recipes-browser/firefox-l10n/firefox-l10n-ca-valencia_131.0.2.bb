# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e9771f3cd7c178ae04f95158c9474b"
SRC_URI[sha256sum] = "eca3112a31153bf11bbcf871871f98322604cba7268f5ef1733f8176cae1d7c4"
