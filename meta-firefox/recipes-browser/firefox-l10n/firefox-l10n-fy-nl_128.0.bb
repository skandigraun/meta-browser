# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "461be37e0ed0226c11a01d3d2a75ea94"
SRC_URI[sha256sum] = "4dc079085cd9433e77168bfd4751c901c1ab2ba73c699aca3237f821e1610949"
