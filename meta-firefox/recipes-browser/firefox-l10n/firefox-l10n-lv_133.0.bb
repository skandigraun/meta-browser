# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b6f28ac7eba04ccee6986b9171a192b"
SRC_URI[sha256sum] = "b0eb92fc3bd8977d47dfc246411b7a997974defc090b3a4c1016cf94e1d25fee"
