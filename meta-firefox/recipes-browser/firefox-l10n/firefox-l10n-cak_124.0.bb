# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f29055e2a3e7ef627987876deb63511"
SRC_URI[sha256sum] = "4a9b86b2f979721dcf4581e0435a3e0a2ce3d76626622973fd251a748a0cee59"
