# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36886d8a84e84a16476342d53df81776"
SRC_URI[sha256sum] = "4fc4881f63c250e75c528c1744df07f5aa1c7f7981198f45420fbbbbddbb2c53"
