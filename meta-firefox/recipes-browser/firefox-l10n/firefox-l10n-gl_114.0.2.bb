# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33b1e7d1f5a4e4e3008b2abff4dd01b0"
SRC_URI[sha256sum] = "43625334645502174edc990dcd540b6d96f6f81f51fd330ccba4f779ede6ea4c"
