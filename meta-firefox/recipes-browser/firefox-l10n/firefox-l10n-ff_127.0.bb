# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f490d97e19b81780e59e21535ac2e98d"
SRC_URI[sha256sum] = "6b482088bdca46764a5b99245060528ac06e3436743c38fbc976f63bf0b48eb4"
