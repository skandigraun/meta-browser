# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2726a2f3ea547a90e4a4fd3e32d71192"
SRC_URI[sha256sum] = "b10ef5560ed7e8b9994bb144e39c88542de633d96380344e21477d5f5df253ec"
