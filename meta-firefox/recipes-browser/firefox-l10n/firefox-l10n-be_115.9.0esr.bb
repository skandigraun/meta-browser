# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b3af516dd38e3c75f226458876678fc"
SRC_URI[sha256sum] = "8d3815372f1ec3fbf8becb31bf551d4a8b369819347faf633d488162b985180a"
