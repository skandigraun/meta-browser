# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25e27670ee31e0af59cf4fcdd4e0c430"
SRC_URI[sha256sum] = "600c8c0c5a3fc558ddeaa1acdc4beee5a5c62b5f2b5c36d0e90abf8771632bfd"
