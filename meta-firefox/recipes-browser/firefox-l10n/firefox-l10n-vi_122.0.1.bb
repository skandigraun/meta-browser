# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2050ad1a8896f6ca2fb33bbe1d62fac7"
SRC_URI[sha256sum] = "3be336fcf253f2030436653978573a3d56061030e9b2eb90d5e97697126f2053"
