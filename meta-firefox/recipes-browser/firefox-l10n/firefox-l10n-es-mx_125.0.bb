# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7eb548c71aa03134dfa4655cf69934c2"
SRC_URI[sha256sum] = "8618146b21f8438c8aa6afebcb4007fc22d91bb86ce15a2aa38fcb8f683600d3"
