# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96bc2a657fdfaa0d6c36ef7053a87d91"
SRC_URI[sha256sum] = "142c08f41900ef8075a4243f3528dde64b31207d32fb5393a5a7158ab7a0374a"
