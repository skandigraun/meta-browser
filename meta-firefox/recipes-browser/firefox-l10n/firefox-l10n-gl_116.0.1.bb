# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8fdce32926bb6c337c145271f3c85b0"
SRC_URI[sha256sum] = "dc111e6e3f0f226acf92da653833a5d5cec639433f700d52c82ab8272e7d35cb"
