# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9217ac97d5843e7e3d92bea0ba3c0ac0"
SRC_URI[sha256sum] = "ee1b13d3f57d088f6d5fdea7b807a92536184fedba05cfe10a5117745ba7b2f1"
