# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a869f7de3e1202fb45ca75224f2732ff"
SRC_URI[sha256sum] = "ff1fad0090d424fd64b24d1a0b415edcf5e82f34b17270035e31fee86a3b6120"
