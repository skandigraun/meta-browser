# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2695393a5633a8b7a6ab2d1f59a460e0"
SRC_URI[sha256sum] = "60c8db05ca6f3b98595753712b642e8f1eb818cb8cc39ed5b1a67b4987d83609"
