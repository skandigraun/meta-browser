# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b3afc2c2a30f0e28f2e15005440cc4b"
SRC_URI[sha256sum] = "37f82852a366552dd0e7a24584721ca2eaee37892604f4ac21a01b21094fd625"
