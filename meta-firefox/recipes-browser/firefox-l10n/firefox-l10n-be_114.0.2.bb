# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4079a15bf9fe2bdc9b2ccce627337f08"
SRC_URI[sha256sum] = "88be55e28b7ff782dd1ec720bb2dc27d3c0ccaff4625b0dee523c6ae359c219d"
