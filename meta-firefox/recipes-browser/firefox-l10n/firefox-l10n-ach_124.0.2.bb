# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fc9d8e7f60aac93b498c5656fe6f3ce"
SRC_URI[sha256sum] = "9fc27f40a25c7f8e008591dda5cad294df8595ad32d75c3395c12150561292d4"
