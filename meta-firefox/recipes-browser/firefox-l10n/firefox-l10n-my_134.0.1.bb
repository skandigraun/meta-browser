# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12666c2215078fe0a40d02f6b8ce910e"
SRC_URI[sha256sum] = "778f5eb2b203da229f3cb9bf33a560afa743d6a26b45e1cd87c38dbf3e9a7d60"
