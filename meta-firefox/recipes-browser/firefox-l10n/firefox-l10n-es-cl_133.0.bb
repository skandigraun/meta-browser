# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3389f48f5b40f33bb418189cdfeb402e"
SRC_URI[sha256sum] = "1359568a488fddb365e6eb806abc656ae409593208162538bc2fd2455d37205c"
