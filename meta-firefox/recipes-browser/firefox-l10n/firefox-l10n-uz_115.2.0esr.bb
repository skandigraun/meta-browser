# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8f3d6518fe54bf985e2c0a1b89021d0"
SRC_URI[sha256sum] = "bda2d1685474a7a8d5db86ee8f96f75953c8128bbe804016419e8bff95c26d71"
