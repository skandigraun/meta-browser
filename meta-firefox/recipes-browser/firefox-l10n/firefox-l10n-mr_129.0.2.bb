# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edc2be51d9560febaf81534568d3b19f"
SRC_URI[sha256sum] = "36481fb546b9cf35e4b552f92579fdea179d52a9ae55ce17f753eb3225410fea"
