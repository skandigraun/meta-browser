# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db32faaf353e83d60379d5aa4a8efff4"
SRC_URI[sha256sum] = "026c8016a44d9071065423c09a24e85e013e611f070b89958f088b9962d7a3d6"
