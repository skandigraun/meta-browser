# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "314943103a7834e1e2e5fc6a522d31ff"
SRC_URI[sha256sum] = "9df479ae24bddd87b7a0ce3c0cc5baaf0e1df8046a68e84dea930a9dc360f3e4"
