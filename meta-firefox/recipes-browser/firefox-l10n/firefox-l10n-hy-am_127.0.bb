# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f695b2dcca44798d27a2155f4f152f7"
SRC_URI[sha256sum] = "ac9500bc190e55d4c350e682ea1dc09920cf2aaee89bc7a8c4e99faf9186f718"
