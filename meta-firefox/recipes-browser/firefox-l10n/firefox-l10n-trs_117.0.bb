# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91ec800c9e25c390c75984f00626939c"
SRC_URI[sha256sum] = "bd1a3ce2a1d9ba125071b7f12ccabfcc5128880d4382736771b0970a1f565c05"
