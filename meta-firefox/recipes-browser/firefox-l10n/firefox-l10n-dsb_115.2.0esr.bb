# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7f0968c7d5fd5bd3616f2560f01dbee"
SRC_URI[sha256sum] = "891b78095a0cb586c1d1066e03b3520feffcc7a9c7e19104e29dbf043c8be429"
