# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd508a353f9bd69a86c40572decabfc"
SRC_URI[sha256sum] = "536ddb90580b9151847e05ad95169a69b305046c75ced879bdcea3c75a199540"
