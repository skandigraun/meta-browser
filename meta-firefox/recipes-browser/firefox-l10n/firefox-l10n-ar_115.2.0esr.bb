# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eef284254c812dc54b1adbb596da86fe"
SRC_URI[sha256sum] = "df50e6290c1b9af1c9f32c1e6885c071fe8ff5af3c4d881a0ae4b27eadea6f5d"
