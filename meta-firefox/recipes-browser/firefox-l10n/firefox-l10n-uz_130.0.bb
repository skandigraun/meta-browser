# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8209f4d64c3aa6983aef530f180c62d7"
SRC_URI[sha256sum] = "82d2b181c89d96c352a1f20ddc2fa457dc75af96c7f1d189d83fbfd7eb847644"
