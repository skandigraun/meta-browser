# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0489c84348d923a4925f3b992e72e982"
SRC_URI[sha256sum] = "a547a98bc0b3bc47f66436e600914f083d99b7effb62a07b430696ea535c9f76"
