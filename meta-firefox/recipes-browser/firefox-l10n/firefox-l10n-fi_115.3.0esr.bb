# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19323163668ee0f4948b7df9f70b9c8d"
SRC_URI[sha256sum] = "35011ace7ede29f6a316a98f3996cc0feb7e69da021b9de0f6c804d3f38750da"
