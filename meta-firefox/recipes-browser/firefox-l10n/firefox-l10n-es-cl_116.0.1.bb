# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b92b19161c56384f9f095eb31fe8ea"
SRC_URI[sha256sum] = "2df9bdda28311f58b16126fc3cb05f8ca7be0c35ae89264ffe549d29097cb252"
