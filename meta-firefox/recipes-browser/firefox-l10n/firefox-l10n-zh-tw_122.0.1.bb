# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3329cb0ab3c5f383326c1b95c16f8aa"
SRC_URI[sha256sum] = "1166e1a567264a734051ddb602440b5512dfb17336a58b17f4b3281ce4372ede"
