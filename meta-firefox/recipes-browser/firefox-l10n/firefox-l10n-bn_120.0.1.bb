# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e487b1985a5874326d7f3b9ec30c34f1"
SRC_URI[sha256sum] = "4b65edb31389ca4c9eb708dd3dce9e7fc5519a42b031d08ca5a95e7a0ae3f0a6"
