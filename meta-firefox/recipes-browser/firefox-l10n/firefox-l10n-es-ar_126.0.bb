# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e306d9b285d5ab85a2632f877b9d440"
SRC_URI[sha256sum] = "8027cffa811dd623244f81b544b900bc672102381e0171b6ea1049921364ef82"
