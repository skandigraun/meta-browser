# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7abe4c17844edaaad6467c6a44e0e0c"
SRC_URI[sha256sum] = "3283008934ea9121e32f184f2d72a8c7d48b44c68b337f9b05b9c604f0fa5894"
