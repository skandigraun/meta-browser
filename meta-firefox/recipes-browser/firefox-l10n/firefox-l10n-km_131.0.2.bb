# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "539be3b4b9a0ed4b693610bf1f856f6c"
SRC_URI[sha256sum] = "1e82bc8bc4bd05d370bba5a619eb484318a95d39085aa2f8dda887e5dedc9795"
