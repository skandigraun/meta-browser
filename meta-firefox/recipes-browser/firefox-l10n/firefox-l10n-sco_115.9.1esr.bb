# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb98a2c4c6c7ee924e3cc714095e6386"
SRC_URI[sha256sum] = "639a221ded5e9d45d8c09be26698cde19ae2b0cd06715cb78f5777364aab8164"
