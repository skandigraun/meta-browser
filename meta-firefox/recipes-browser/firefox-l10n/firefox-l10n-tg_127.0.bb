# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac0d501110ca4ffe5aeb95dc5814ee94"
SRC_URI[sha256sum] = "9afce57f9cd8bef207cebc80b8c531cacb9fc8d146f82cd17fb321878ccbbc77"
