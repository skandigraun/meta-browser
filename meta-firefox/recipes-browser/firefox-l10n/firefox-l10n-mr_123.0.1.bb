# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77e380a9a2f95782ad123b34ca9d24ac"
SRC_URI[sha256sum] = "0d85e7d1a6ef309d1eb94f6419db835404bccaeb25bd48736a8671766dd748f6"
