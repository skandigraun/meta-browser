# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f248e3e057f759527d8fe4171d4684e"
SRC_URI[sha256sum] = "b300ebb458f1bb926cc08c266cf2d92a9c9b3a0d7667d10cea3d7b7a0d0f6d94"
