# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc0b6462f98cebc0a86866048d15c05f"
SRC_URI[sha256sum] = "aceab0367c0387369bed03e99672dfce0c13c68d9035692060ff8081e3c1bb34"
