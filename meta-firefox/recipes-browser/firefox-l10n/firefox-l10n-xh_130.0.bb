# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbce870f5d77a0eba535da0f9408b2dd"
SRC_URI[sha256sum] = "a4fe685b47f59a53a647c9f25cad358acb45d83f0f375eca9f1fb855d85e6ca5"
