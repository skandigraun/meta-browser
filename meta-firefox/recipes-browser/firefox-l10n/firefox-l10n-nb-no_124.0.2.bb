# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2e3b5b2a573b3304363bb44b804db54"
SRC_URI[sha256sum] = "669c0c16dc8d5d42274d54bf8799be5d52fb9147c3fdb1ba561914bfdae0adee"
