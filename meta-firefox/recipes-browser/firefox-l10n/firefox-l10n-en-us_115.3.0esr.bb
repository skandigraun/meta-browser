# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd092baea8261dab191c521c4be8c565"
SRC_URI[sha256sum] = "4fb8a19546fd36fe6ac0255163efe9ac597658d309bb12a7188a8bb0a1c3ab46"
