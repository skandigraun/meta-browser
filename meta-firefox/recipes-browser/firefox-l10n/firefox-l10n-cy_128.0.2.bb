# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffec8d1dcdc1a11f5dc3146a647a6eb4"
SRC_URI[sha256sum] = "06aec97053ecfca1d2c9c84b634b92fd5e7b05f49ab8d0d2c1c26d77a62fe0ce"
