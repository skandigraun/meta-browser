# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf2dbe546bd770d0689e35bc5d9e2824"
SRC_URI[sha256sum] = "f1e18c495b0376e8451b679b6d0cba7fedb1cf47bcd7e814a7221a2a96fffcbd"
