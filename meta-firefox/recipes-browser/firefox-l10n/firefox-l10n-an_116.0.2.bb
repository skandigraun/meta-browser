# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39ebf174296dfd89e44ada6ea947920b"
SRC_URI[sha256sum] = "eb648fd2db86bb66be7ee15b3d2926b35b44c1907f74b33922460cca12d4eb37"
