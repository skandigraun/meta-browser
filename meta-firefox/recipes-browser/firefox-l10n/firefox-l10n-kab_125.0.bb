# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f81f231736f253994d5b519bc8eab525"
SRC_URI[sha256sum] = "4cf6ebd75078dc2d9541f6f451357baaa9de6a2e20a683387bc43603a9747a7d"
