# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d37375094f6a4eec781bbf17f4dd8b0"
SRC_URI[sha256sum] = "8b11f723ba5a973cf3639fa03e860e29f7427c8d8e68d278d5770ec83a6fb903"
