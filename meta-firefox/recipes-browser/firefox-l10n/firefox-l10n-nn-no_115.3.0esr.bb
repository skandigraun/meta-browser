# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f37596a826d86d08f080714c71e7024"
SRC_URI[sha256sum] = "195efc607a9bb6da62cef078c19b7e9c01784d92db6d2f8669965dc8dcfbd384"
