# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a850db671aa0daf30dfb04d13dc3721f"
SRC_URI[sha256sum] = "0bfca53733960476aa8f4e48bdb479c93ed778d61c6e9f10e0cb90795bb8a412"
