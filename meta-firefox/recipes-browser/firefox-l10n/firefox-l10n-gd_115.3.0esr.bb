# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "472a5a6b732f3d60fa79651b24033396"
SRC_URI[sha256sum] = "ea7e1b05278bd0cf0bd494cb92ae1fe6cb3b0213c344a6ecb530155a76a9f51c"
