# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c9d4af2ed3d84d7ed87847970d82ba1"
SRC_URI[sha256sum] = "b2a2f44d44f7113c6e02d05d8a481afc05dcd49997af03439d86099ad1f24652"
