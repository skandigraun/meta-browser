# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1db540bc3628898cac54787c9ba7865"
SRC_URI[sha256sum] = "ccf8f69bf0587cb3c35ba89f79adbdb22245397b0317c8954446ca0ab1b0b254"
