# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0026b8c97cd2b8ed266b00467b12225"
SRC_URI[sha256sum] = "92652e143c1bae6b9196fde481835fda420f46e0ba4960cfea8a0c9ed17299d5"
