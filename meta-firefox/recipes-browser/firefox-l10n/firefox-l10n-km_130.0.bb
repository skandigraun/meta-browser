# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d16ee8caec73a7516604f2651d3a1255"
SRC_URI[sha256sum] = "3a09b5b1c5051b6a5f08fed94717aea4053a335ade0ea90762d4e14aef8349f1"
