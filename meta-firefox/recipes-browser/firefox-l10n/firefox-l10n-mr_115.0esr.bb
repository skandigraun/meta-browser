# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "676577573837b36a64f9773dbfad2225"
SRC_URI[sha256sum] = "f64faec690c621ec66d6b5e242f4adb9490ff34ca0e2a498dbde85fea6abf2a4"
