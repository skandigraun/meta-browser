# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b23f617b1941e2101b5bd060f12c041"
SRC_URI[sha256sum] = "289d502afb2e73958aaa249dffeb031a7fa0041c2040a01fbef7cb8fc92f55fb"
