# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4db62c79434149214908c49ea939195"
SRC_URI[sha256sum] = "73dc6346e21698b5ac3da5e95b06b3d3c69a6c9ec141ccc89d8c462863441642"
