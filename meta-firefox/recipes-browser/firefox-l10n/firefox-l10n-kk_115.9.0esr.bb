# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9466428e161ec0e9d2c896da86cf6533"
SRC_URI[sha256sum] = "719cf7019f5fe6ebaf01853d934dcb9c6229bf0235c12c7efd67fc6857bade2f"
