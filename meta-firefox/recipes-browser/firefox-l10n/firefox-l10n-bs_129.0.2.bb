# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5baf83ab53fb5ba320b6ff6f72a165f"
SRC_URI[sha256sum] = "5b9d3df0c4c3ce7ad9ba53f585df8306a0cdef203e38fb5350716a7eb7fa43ca"
