# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cd007eeeda3a9e5d804398257e4dd9c"
SRC_URI[sha256sum] = "8a580b7270a81a4077ab3f475b2263635f8b4a32ec60d6677223facd61ca5eff"
