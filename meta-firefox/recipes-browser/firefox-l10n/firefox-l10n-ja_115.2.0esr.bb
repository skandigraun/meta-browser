# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b9213ebfba2147e7e71dfa6d77d0326"
SRC_URI[sha256sum] = "a8bd8f096da96414ffcf9f047c84589bf768f6140b5d7ccae887b9733b0e0b81"
