# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acc4be8653050220b8de04b4973f5f46"
SRC_URI[sha256sum] = "3e1bccfc26426c2ef93dd2be74ec46401b3c52c0b87bc5d9a310e989ccb76469"
