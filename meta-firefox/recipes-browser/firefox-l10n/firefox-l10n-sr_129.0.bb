# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c672e8a978238557dea8cf9ca1d06b7c"
SRC_URI[sha256sum] = "7ccb9c7dfc04f240626ca393c39f93215cbefbf19fbfddf0f976ceaa920e92b8"
