# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6313cc2bd43a196556e3e6e762e3edd5"
SRC_URI[sha256sum] = "6b5b04965c23c68ce1e62c356c2c3f87d1b19131c498898959ef7b7fdba3a49d"
