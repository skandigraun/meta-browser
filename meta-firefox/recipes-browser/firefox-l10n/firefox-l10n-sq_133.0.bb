# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b74a3d13f0298ec0b56a120573e58fb0"
SRC_URI[sha256sum] = "fb3a32fa8d495ed0c2c4b4714750fd62d9a786eee839548ef80e9f4dfec26db4"
