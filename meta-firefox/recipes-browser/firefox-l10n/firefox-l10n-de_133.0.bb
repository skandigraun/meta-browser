# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6a2377b55adc1e1274f85719c9afaf2"
SRC_URI[sha256sum] = "c8cb593ad3962af6b42279641582f48d49c22afd859f19eac54ff714474e0284"
