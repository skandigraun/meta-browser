# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec907a93d86f3b7ec20d50a57f86edce"
SRC_URI[sha256sum] = "113a73c53524b38c49e4e5db5fe7618d92b3db12e0df0f7813ccf41ec70bddf8"
