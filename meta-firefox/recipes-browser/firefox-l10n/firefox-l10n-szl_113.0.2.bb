# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae6ebe4570542caaf2eab6674fc14dcf"
SRC_URI[sha256sum] = "b2021bfff787787ee78a042c6ea5dbb16e7a46781ec160b1b8a693b80e4e8c4b"
