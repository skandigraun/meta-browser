# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02c94397da7dca9e7e450b0428673956"
SRC_URI[sha256sum] = "88ef635f97be785390d2d6391a82340fbe4af2bab76db7043e0d794587f716f1"
