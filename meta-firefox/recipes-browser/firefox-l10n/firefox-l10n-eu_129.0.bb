# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "145305091b621506f9a7e22ce4e94ff8"
SRC_URI[sha256sum] = "063074209f06833f158b910d0b382ae19e997bdac866b77f80598539508f67fd"
