# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "657b10005b332f5dce73a2fd5cb21832"
SRC_URI[sha256sum] = "c50142edecd57e19739c49afc74aa05f1a46d16018b461b734e8b49ebc94c634"
