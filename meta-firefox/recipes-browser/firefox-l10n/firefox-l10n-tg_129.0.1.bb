# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d87222a03ead9a77ce341bef63c35aec"
SRC_URI[sha256sum] = "4165601ba2a48bef4d7d0d4a712720af7fe7f8e9e2c2c01b2a1fbb8a90f3e86d"
