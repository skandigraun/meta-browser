# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "169251bc468f08b54baf4ff45f2bb5c8"
SRC_URI[sha256sum] = "54b91e9dba28544cc858ede65c4e47069ece4761f91316451b30736110c2d8a0"
