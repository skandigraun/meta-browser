# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "456b56f996a4eac3e76af167100fd0bc"
SRC_URI[sha256sum] = "7b8bb355c7515ca93de43e494762b0afdb8219d91ec16b27a3cd78d7d6c5e681"
