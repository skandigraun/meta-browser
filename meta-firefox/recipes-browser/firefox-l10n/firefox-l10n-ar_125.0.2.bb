# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69d3665750f4d1f199e75705c2520564"
SRC_URI[sha256sum] = "92e0b9c6b7d6034d4fcb69521558a75443db72e2c6c1f0d0e2cb3ee17f6f0f6d"
