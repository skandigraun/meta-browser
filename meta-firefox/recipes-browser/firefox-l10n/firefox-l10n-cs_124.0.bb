# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1016e4a643d7e588bb5996bc0d94f5"
SRC_URI[sha256sum] = "ac526e9d030063406f6ade11d99455fda7e478f5dc68dcf67a46a7a4d50d8d5c"
