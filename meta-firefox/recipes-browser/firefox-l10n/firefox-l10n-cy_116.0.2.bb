# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69df4be4f5f240c2a9bf3a70cc93f23b"
SRC_URI[sha256sum] = "c483683ac5fd0e3e2025d5e95766e21d61a415002d85a1540a4e7b4d6221efd6"
