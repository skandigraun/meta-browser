# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c08400361e37a29194524322fdd6706"
SRC_URI[sha256sum] = "265e48999200def0c487d727996808c3bd7500051c20745eb1f18248466d01c4"
