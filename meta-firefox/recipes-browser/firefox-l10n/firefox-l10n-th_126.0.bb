# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fb62e6f92cb2fc511d76712952cdcef"
SRC_URI[sha256sum] = "7de5bbd6f63074f27742c564893daa9122ad3a9056bb07015f9bd661fbcab23d"
