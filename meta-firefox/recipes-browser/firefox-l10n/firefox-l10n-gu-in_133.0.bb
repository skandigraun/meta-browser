# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fa175fd70883c9744c0c3e5adb74bdb"
SRC_URI[sha256sum] = "5eb29d6dcc2976976530bb74dc5ab937b0c167521c30c204993799691c2c96b6"
