# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abf1ccd46b030759cd7595319203f634"
SRC_URI[sha256sum] = "512f460c3dfbc28b77853abb4532e63c4723e72e65c5678198e919ebf0b06798"
