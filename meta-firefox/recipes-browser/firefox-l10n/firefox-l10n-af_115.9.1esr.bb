# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57928daa6303ed87dc2d69b96ce27399"
SRC_URI[sha256sum] = "88fb0b4877795318e4be7afe90cba826f2b7b5feb9a253aeb6d24206f8343453"
