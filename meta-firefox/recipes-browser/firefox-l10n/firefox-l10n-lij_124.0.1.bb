# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17f60f18299877fc3caeda4791d3060e"
SRC_URI[sha256sum] = "f0837698b49ccbc8ff09ccd4e689f6bd9d3b663bfc42f5280bf21371b71ac809"
