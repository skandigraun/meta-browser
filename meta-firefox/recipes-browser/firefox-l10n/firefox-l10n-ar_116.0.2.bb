# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfbc1adfff4e2643e9ae0bb1680f49d6"
SRC_URI[sha256sum] = "051294821034705b7bd60dfe763e0eb2316b6b2be8b96594cb8b1ac134339c0e"
