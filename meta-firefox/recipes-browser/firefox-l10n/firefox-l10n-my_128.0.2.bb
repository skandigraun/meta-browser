# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73dec04b9cd1093ff99ec269658cae8b"
SRC_URI[sha256sum] = "7d634ef5340763ce50c2ca6677a559620da80abf99d09a033004ed73f0d03de8"
