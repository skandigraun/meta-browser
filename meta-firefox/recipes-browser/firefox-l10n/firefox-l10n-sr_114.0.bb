# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "130d8adfe34cf1786d0c399af374723d"
SRC_URI[sha256sum] = "5315ff187fe3fddfc39000a7164ff3b42938059978eb322ba222a43d2a1145d1"
