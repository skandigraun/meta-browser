# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1d6e81a474ddfa852b2cfa0acb96b8a"
SRC_URI[sha256sum] = "b6cec0dcd22a1da28afc3a14b2bbb8154723937cbae0a7c21141e9a8185d7411"
