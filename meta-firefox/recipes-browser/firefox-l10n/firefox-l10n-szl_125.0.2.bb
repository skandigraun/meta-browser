# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a13451a75951bc746873166810dc6d50"
SRC_URI[sha256sum] = "4c6baddf37f1db18b960055f77f2ba5e728d3c7461319eb84c6ff20f43e7237c"
