# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c498d172879189991626487bf275943"
SRC_URI[sha256sum] = "e2aed7b94109ffaaa83384baff6a9d62c531cd0e9a3d2ca42a37db7f48ffc8e3"
