# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "245ef27435e85f362dcbda6851d750f3"
SRC_URI[sha256sum] = "3a7970bd2933012416c9507aa4b04a717294a3994b879119665a4b8a07565e35"
