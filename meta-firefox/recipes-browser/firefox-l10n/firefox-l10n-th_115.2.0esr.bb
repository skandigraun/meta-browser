# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9f852015f540b316977410c2555df4a"
SRC_URI[sha256sum] = "347e01fc6e0298e49a33b52f096738bc5c3d3ff0b5b47235b5559c7515044058"
