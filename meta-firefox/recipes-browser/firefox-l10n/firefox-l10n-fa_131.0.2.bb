# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ede838cc223a41e40346753ce5349d3f"
SRC_URI[sha256sum] = "fa079a3768e2639631e35dfe58ab633fc92037810c7fe5750ec4719446bbab65"
