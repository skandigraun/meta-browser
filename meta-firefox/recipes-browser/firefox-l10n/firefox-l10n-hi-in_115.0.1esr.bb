# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94e1e9a186f83dc1183833388f049b81"
SRC_URI[sha256sum] = "3cbe5235dcd739f272b66ad082261670e121c7ec3ac90a9201c2ddf083458291"
