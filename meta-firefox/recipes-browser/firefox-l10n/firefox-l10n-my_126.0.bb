# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0ffd883d8d01c711a950a4a3b5a434c"
SRC_URI[sha256sum] = "06c6003fc277fedd930b7f906dfd826418b7fb27b56032af1ec5d2f1cd03dcbc"
