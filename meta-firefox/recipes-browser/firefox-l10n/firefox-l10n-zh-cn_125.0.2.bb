# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1aaa09dcdcd1574ee32704b6c3f40cf"
SRC_URI[sha256sum] = "1d679ea73c8fe3180183ebc84e04707fa0fc7884efd4ddb19c9faca8d1b0ac4c"
