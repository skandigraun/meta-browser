# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a98362667d630275caa99d9cd6b75ef9"
SRC_URI[sha256sum] = "07d3b149ffac36178e477f8d62cc2e1ee91e0c89171a3dbf2b7fb2d13c454144"
