# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06a90a2d7ba2aacc1481f354567bb379"
SRC_URI[sha256sum] = "7f123089ac27a5b6d973a708d616c64d69a42487cb1318ed2f10f34adff6cb70"
