# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d6ed929f8a107ba2d1b8665777270f2"
SRC_URI[sha256sum] = "a2caa15529a5c4773a91c4bd597afdb91470d617aff0a724debec9727186563b"
