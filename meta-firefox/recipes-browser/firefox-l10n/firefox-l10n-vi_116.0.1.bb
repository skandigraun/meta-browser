# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a1708279626bb0fc69464ae951cf58c"
SRC_URI[sha256sum] = "e5bc53aa69a3f17b24425b0cac5838f5c43ea25f01deda248316872980e00ff2"
