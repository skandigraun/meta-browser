# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f390eb418bb5797224e62362be518e15"
SRC_URI[sha256sum] = "312fa6a1c408eef4fe4c58e6359747d363759deea9b146453c20a8498875ecfc"
