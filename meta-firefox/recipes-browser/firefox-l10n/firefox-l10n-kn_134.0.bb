# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9b2de9337ae80e6590ab1567d98c343"
SRC_URI[sha256sum] = "109de67210784a0d81e8e87cee9c7a1f704eb2c089ad4f9e813e7291fd52854f"
