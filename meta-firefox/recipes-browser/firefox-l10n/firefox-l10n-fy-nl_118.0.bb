# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b8a0790199516de151f8f4e9b2174db"
SRC_URI[sha256sum] = "8f83bde793798bf91033e8a00e961cda6a99256d0d0412f1150a7c2d2853f27d"
