# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50542b0e8f27c16d52bafe35311d76e2"
SRC_URI[sha256sum] = "eace1c83757a384b6657c30e3e2c51b22f51ea10d686f400887cee7e0006ef82"
