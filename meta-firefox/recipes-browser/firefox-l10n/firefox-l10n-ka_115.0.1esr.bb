# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af86a54230f1f9987f8d48f052efe059"
SRC_URI[sha256sum] = "fbc4d8b03ac8ec6892324a76c1f272af0a77de9a5d9b0cd9dcf4f082c38edae5"
