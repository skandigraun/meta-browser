# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86529f583750199713c0644da759d278"
SRC_URI[sha256sum] = "8f44c3e332e3fc8728a3c18ec7f5c9d9481dbc1a9fda77067b71ebfa369e9923"
