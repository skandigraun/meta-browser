# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90ef22c09bfa5ca80f61eb0dd193871b"
SRC_URI[sha256sum] = "58d2cd07bd8b4db426fcacd7a1996ec59cc6eb68a622cbec697fb47a4a09ddaa"
