# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83cfa0033467bc84a964d68c8b73cf2e"
SRC_URI[sha256sum] = "cf3a9358608fbbd70d896a75897c7358cb8b5afc4fcf861ee7ff6fc27a7c58e4"
