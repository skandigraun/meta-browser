# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4630c5285780caa0b4881fa80660df7"
SRC_URI[sha256sum] = "3cb716f083d8c3c77d2827997778ec50c4c6697a46cb1aca67310ebaa27a76de"
