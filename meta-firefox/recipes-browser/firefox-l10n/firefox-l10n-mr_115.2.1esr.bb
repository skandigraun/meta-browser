# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c98321fe4766b2efb309199e1fa2455"
SRC_URI[sha256sum] = "ca274732b6a61e69086ea6bee689273f38d9b17af946e3f8b6b4d63b5872604b"
