# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dc178bee765b513bca9fe1a44fc9292"
SRC_URI[sha256sum] = "2b327b18dbc6f118d7785be55ee192ede0f9cccafb7f6cdef6dc01a633dc154c"
