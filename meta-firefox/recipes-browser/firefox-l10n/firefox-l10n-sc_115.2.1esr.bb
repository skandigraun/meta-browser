# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbd9bf5b3c8dd513048fbc9fa5bb2ff7"
SRC_URI[sha256sum] = "6d41ead739842b1206a85c7115a08e335e76e7f51a71954b1eabb85e59b62e4e"
