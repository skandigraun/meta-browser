# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6a700a7c18fea86ef8489a048eaff33"
SRC_URI[sha256sum] = "b4cbe9590ee0e0d7f26588a1c819c970401fd38d14b1c080021b650e49dacc5c"
