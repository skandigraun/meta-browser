# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b092cd9b4ea4bba13c183733a5fd665"
SRC_URI[sha256sum] = "3a5c1ab68626128d4fefc1ac1a9c1925ab72de4c46a2dc136c5899651f45e7c0"
