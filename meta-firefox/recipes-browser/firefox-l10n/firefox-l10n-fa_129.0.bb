# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8ab398f655ac3da4121fafb4338a0cf"
SRC_URI[sha256sum] = "a2f87300690dbdfe4ba335772eea260bb95b3936fe04292a430a4cb1cc50547e"
