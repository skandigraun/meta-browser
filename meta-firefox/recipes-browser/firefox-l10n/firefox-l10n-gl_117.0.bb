# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa7bedee5eb5f2f8406326314d2f8b25"
SRC_URI[sha256sum] = "c655d8b53cf8766832d6bc0a6412695df4aaa055b5615fafa0e84dac93d516e1"
