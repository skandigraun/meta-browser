# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7ff12a7e269fa800353663d7b35cfcd"
SRC_URI[sha256sum] = "abce5a49c295b987c63942df06a7b1f63ce6cfdbfe43fbfd98cf89757f133211"
