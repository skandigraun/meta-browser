# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea11e0966d8bf83bdf5c022d9619f124"
SRC_URI[sha256sum] = "3cd42f43961b73a81703e0af1484cccd6bd59e2b1d06cfff9ed020f652588e45"
