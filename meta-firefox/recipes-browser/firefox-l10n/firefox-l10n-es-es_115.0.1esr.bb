# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08482eefdf73ef5c37e2687d170356cc"
SRC_URI[sha256sum] = "f2d7507285f80ca986a2ba4d05139de762f8967945c126bc233a4f10aa8a5eb4"
