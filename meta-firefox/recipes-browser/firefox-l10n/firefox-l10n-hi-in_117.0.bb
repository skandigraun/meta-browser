# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8880bca7dca119f383a4ebbad1ff0878"
SRC_URI[sha256sum] = "ad176c655ff1a02aec6f02733338250ed35ed9652a6662871b764deb241064eb"
