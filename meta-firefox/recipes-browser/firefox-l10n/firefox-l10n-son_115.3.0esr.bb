# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69490782bc42c2dd371df757ebe40002"
SRC_URI[sha256sum] = "281b6ef20e645b2a6e53d59f1303ecab152110287a0feaeba9c40df6aa30dad2"
