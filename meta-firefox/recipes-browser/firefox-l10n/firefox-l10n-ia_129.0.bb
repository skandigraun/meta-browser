# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8dd39c8cdbfd9ee5ea2fc70b104214c0"
SRC_URI[sha256sum] = "113e91391fd926cb037fa9b5051207c919b9736cc5991ebab0afdabeadede1a0"
