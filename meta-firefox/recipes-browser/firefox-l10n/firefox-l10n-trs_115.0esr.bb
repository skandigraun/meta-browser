# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "687bd22c009e760fb594ac59c0d665b3"
SRC_URI[sha256sum] = "48773bff1ce6dcc4dd1c676aa83ba3d55d6bd0612a6319831a3e7a59143cab5c"
