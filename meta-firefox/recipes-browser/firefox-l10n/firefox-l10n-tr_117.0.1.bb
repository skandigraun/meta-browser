# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c0678bc9cffdad2ca8870bdf4a2baec"
SRC_URI[sha256sum] = "6c45cd635cc0f1932dddc4729f6c07aed95e5eaea5251fb4670d5c3000bd79e3"
