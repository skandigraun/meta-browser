# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e398736d99bf5d79a727525ada4628be"
SRC_URI[sha256sum] = "299bf3da92f5e38616a4a4b542587885d67224d3f68ab82b808831f3df96bfdf"
