# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb0a1d358fdb79eecae33b9e80999368"
SRC_URI[sha256sum] = "e36588d60709e5a5a05b10186dd05e277cb264bee908eb7cc305f18c7cdfce43"
