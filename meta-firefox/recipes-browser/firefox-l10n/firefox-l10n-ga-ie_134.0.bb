# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1e502d2730a1b6be13e001ab74f8289"
SRC_URI[sha256sum] = "bdacd2761e9bd7c490b8b0eade5ff94b39677d70e1556681a5bf9361bbc9a4c4"
