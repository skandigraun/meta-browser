# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2e9cc1e886682c7648f27c7d221c6be"
SRC_URI[sha256sum] = "5216f89729b64c17f47a05c37e15d62cec55816b407024e6545b3a37ebe11a1c"
