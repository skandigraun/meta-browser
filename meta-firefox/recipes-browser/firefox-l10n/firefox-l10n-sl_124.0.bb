# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaaac336dcdff8241c3e193a7c79deca"
SRC_URI[sha256sum] = "93b5c8cc37c0460a97164810f1db63d30938336790f078eb9b3e9da5ede14b9f"
