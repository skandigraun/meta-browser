# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a057e1604dc71efd90e90417125799c9"
SRC_URI[sha256sum] = "c6f048e61b6655d8d76cc30a80124d81027357ffd5b877d575fda6b920fb34e3"
