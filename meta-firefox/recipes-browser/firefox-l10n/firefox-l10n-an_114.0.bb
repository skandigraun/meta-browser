# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c26da2d557cb38f28b8416fa52d4a9d0"
SRC_URI[sha256sum] = "5275570c342f09f90a735bb264810c7f4ae1fbc8e18d9a4944a95569682daf62"
