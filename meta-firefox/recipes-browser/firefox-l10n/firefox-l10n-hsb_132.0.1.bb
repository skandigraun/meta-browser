# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "930171f42de456d923a25fed925aa4f0"
SRC_URI[sha256sum] = "6563b06b1a6f8bf4f49e2270f00998a2cd43d5530feeb795b032d491a2a95a95"
