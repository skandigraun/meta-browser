# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "275d5a5bba0f0d86d84b986e8c642964"
SRC_URI[sha256sum] = "c950ec5a346160ad09934e02063defc7991270241348aa0ce34645304d8203fd"
