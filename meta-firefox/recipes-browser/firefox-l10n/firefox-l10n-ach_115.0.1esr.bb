# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dda6a681506076992c792d7d2325922a"
SRC_URI[sha256sum] = "bbefc158369c27255adfbe3def24d49d42190f6a5aafce2c3aefbc7ede731c3a"
