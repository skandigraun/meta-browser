# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc57b12fb4f390404af43a240dc44611"
SRC_URI[sha256sum] = "3b4103a8a98c922f1b19a4eeff8e1848207e251db505f0f6f0d3e24df8fae303"
