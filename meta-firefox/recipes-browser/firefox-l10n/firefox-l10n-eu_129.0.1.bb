# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a250c5b18f6eb62fca48cc1499b47eb7"
SRC_URI[sha256sum] = "5f7c0451e5daf5260fcbb39dae7344746c12569891fbd68b17cdcfa517ac6474"
