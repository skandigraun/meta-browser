# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27ca01866444e3906ec52154591c419"
SRC_URI[sha256sum] = "757f757e7d36a988529831351e70469c83eee2465466151646e1266b2ec2a43c"
