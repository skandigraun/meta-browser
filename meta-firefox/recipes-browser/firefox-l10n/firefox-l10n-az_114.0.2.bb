# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25b5edafd081d92353a4342e03a4be2d"
SRC_URI[sha256sum] = "1364e5d852eb8d93eb702df6850662361d47624c23dd210707d86b6f59dd98e2"
