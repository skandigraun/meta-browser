# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24dc773ea41dfabc8d9f0ca6585420be"
SRC_URI[sha256sum] = "0ce700e28276ddaf987effef8142a4a7a00829a77b981ab541b5f62fd1f395e3"
