# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49d92248ba59922f5aa89e40d1a848da"
SRC_URI[sha256sum] = "6f07eaeb42e894acc33f2a1cdf171d7bc578614e017279edec72ced2980a7768"
