# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "361cccec700477791caba965e15a3bee"
SRC_URI[sha256sum] = "51baa32a3aa0fad64e91e8e09dd1b599d07f6d072e21b9af27be943ab6001f3c"
