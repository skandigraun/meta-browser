# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "662dcf234433728ad309f8957d2d358e"
SRC_URI[sha256sum] = "f8021169bc1f7e1840cb367e9b287a1d2e1bd91d3c567787c6828376f5ea5fee"
