# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b20a45d6b5abe0700f84a070579e385e"
SRC_URI[sha256sum] = "57fa974400e8a51aa08065980217cc2c18a0291c4b8c13bbd8ce90a682ee3628"
