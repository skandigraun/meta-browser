# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be3120ed53901c4cf97225754880446c"
SRC_URI[sha256sum] = "6152c53a38c3fb6853923e3f46be852bc4b997b431b521f893c371b1aa9580d1"
