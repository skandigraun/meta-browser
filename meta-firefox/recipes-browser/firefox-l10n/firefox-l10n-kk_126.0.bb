# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "740dae24ef6a236beb3b24ab30c7e080"
SRC_URI[sha256sum] = "c044468801c7944bcb073c99e74616b055f79cd7b63b99242511c7834df33e1e"
