# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eba479e521fc5be4d8192392703cdcd"
SRC_URI[sha256sum] = "e8ad0de12457b740ed713c3f181a06bd9a011dfcd7d5de9c0b96c7374961695f"
