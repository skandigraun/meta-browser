# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2df31fab989e6d39c64f42c027e0e25"
SRC_URI[sha256sum] = "c8808a2288bcaac58005977cde797767b3ed0b7f25a72bfb9c17ec9ec84ff68d"
