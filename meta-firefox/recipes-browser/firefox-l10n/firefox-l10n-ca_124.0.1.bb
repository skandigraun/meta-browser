# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa5951bae432351881efac84481c040a"
SRC_URI[sha256sum] = "9c32ceae4e080db4a6c04b4e4837cadf7ad69348367aab220b3b61e826094311"
