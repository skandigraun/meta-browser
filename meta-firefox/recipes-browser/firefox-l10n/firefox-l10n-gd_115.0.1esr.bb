# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f14236879897d744372d177a647322d0"
SRC_URI[sha256sum] = "55c26f37625d71572ef413d51e12ffa64898e0f4d14c0ba6e15dd67da22c769b"
