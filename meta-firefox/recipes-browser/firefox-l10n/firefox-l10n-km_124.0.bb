# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "970a225703a2553e3ca9ee6b6f1b2902"
SRC_URI[sha256sum] = "1b14b84836afc98674ef13b8172163e2dfc9000503e84214805e8678d728fd8f"
