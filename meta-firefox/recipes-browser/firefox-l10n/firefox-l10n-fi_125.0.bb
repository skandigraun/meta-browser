# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4309761162327dc6938822f1d1de6c8e"
SRC_URI[sha256sum] = "2cfbec62ba8b5fc4bc2b23d2c7f6e1e385109f4089731a076896a54a2dcdb179"
