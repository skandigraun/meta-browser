# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c5a30a0308d4da00c1411626263c4f2"
SRC_URI[sha256sum] = "a42e9fc7532a840843a213f71c5ce500b88927a76dba424395edabfa97d0dc21"
