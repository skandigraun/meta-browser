# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b7d7db884653ed470a23f9efe48e434"
SRC_URI[sha256sum] = "704fcb6d75e448b12c567c9427b39c32aeb9c12080ed99843da912b7a5b30078"
