# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39e590885f21098b3ca3a8e5b58cdad8"
SRC_URI[sha256sum] = "e49b3977cc8dcb3d0dbe90e3239ec7e1597f39f943247cf027d86fe8fafd8d4b"
