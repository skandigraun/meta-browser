# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc9bfdbe74d24457a4588f944964239a"
SRC_URI[sha256sum] = "e04c46064dcd89baa5bf9f02c475b49954602ae2f96eff24680f03a36943bc17"
