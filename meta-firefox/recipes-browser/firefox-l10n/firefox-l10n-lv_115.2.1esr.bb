# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b96e503ccc6ded8ecf962dc10c0c4c3"
SRC_URI[sha256sum] = "887bfa3e220355c5cdb81f436a69ff37df4c44a5c28b82727269d085c17eb557"
