# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44cdc0713dfcc3b453b055d696167567"
SRC_URI[sha256sum] = "b2669732d6528c7571327391d9d67f86cdddd124ea5737d0ffb51820260848b9"
