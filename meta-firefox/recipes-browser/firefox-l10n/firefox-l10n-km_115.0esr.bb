# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "014b2c1d81bad7266a4f9449e4d00152"
SRC_URI[sha256sum] = "6809590a3c369f4995b3ba366685faf78370bf9c7240851315a8c42ee3130bdf"
