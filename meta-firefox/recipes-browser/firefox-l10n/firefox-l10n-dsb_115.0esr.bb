# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39c57cf9aa2fdb8591a60f2aaba4a03b"
SRC_URI[sha256sum] = "77743d6805ec4645a6f0612f91cdb76b484f457e140967217092df3006b19dd9"
