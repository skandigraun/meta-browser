# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "891d41441e0775bc070d9b1c555d7f48"
SRC_URI[sha256sum] = "b1cd7e94142cca2f64dac57ef0eb2e05db9f0154c327f7e2b8b4d04e651070fb"
