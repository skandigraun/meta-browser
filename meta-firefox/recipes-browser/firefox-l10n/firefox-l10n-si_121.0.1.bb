# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d60e11071866edfeb6119e9def6b96c3"
SRC_URI[sha256sum] = "3477b1ade038a6cf5e0f7fe0d72d4b9d2cc012db9e0b844c423e6f13223b6304"
