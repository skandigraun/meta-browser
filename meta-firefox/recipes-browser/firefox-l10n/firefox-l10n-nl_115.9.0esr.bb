# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02a3cd0844fe810dc0bac3230713498e"
SRC_URI[sha256sum] = "4e2dddc7531d5766f19859608e6d57c4cd27dcaacbb6613a205ce5ab1f94f914"
