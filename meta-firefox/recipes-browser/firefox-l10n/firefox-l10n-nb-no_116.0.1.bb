# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c045c3b6b2b6477869dbaec902ca2d1"
SRC_URI[sha256sum] = "6b4523dd7cb2474a54966f0b71353613e336b2b05ab4fe2e8c5cd2150f9a2718"
