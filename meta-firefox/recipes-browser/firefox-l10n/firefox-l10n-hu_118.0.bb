# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9f2d0c42467d32a7b87beaf6c24972f"
SRC_URI[sha256sum] = "cff2a624daf6552f4dcabb5b4941b340befe3a7e478df1aac341516dd53f1116"
