# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4102f3949ee39bf4f5d7d131b8c62b73"
SRC_URI[sha256sum] = "2c48207cecafc9d9aadba0185478da1688539b121bd91264a5aaa4dfd5cd09b9"
