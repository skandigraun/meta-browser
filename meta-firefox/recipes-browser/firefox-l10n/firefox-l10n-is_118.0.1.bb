# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "214515405ba572149259e168b6443760"
SRC_URI[sha256sum] = "19200e7b0343df81a035a2a48b05c0d2123c3dab2336d958b551bfbbdcdd155c"
