# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cac93865b0ad8bbc2a61c02e6a1df2b"
SRC_URI[sha256sum] = "f881219474b1eb539346325c653a68bd170f9af3fd12c844dec98931b1a9e3dd"
