# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c386b79788dc391e92b8f67664c183b1"
SRC_URI[sha256sum] = "9aa454be0ed360e9331ae56d2a66117759cbb99521ecb59cc432985e0e694370"
