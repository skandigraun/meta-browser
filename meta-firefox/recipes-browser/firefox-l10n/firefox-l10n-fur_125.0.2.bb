# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "739d8a639884f68aecb3c7349f9827f5"
SRC_URI[sha256sum] = "da60415f9733bd4328d261f79f5b7cc40585072a9dda12138cb580ec3f823997"
