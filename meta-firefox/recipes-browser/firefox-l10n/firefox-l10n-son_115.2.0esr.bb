# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79a7a43b2136880df5e56c4c479f0f4d"
SRC_URI[sha256sum] = "7f5d107d4b4bb6d6cf316a01c98490260f1953e4af766db2a83c7af148229e76"
