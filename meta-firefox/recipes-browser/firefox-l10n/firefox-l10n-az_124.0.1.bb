# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "379db798294f6d703d74ccdaff68be2d"
SRC_URI[sha256sum] = "1c10362dd7b4338255f64c66a42e7b6803073c1ececf89d5f8ae64e4a1480546"
