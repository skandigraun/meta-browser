# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "366a56efaf76d72c550ad02f6bb6476a"
SRC_URI[sha256sum] = "9e4d159c4e29f477f8b286f703549724a8c26175661722a061f3bf2e13bedcc1"
