# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84393efdccfab50c594eca906936f054"
SRC_URI[sha256sum] = "2e0b4b6274479477d1f152ad79ed87c3c3903986104c5e87ee304878a7ad55f6"
