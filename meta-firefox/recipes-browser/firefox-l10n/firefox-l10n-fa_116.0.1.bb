# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ee9ad6a0e0af24a009525a9269a86df"
SRC_URI[sha256sum] = "433391491df458c2c80fece26b54b03eda306cbd1cd96c66597245fe60511b3a"
