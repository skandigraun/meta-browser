# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "addb0973614caa2e1684cb93c033307e"
SRC_URI[sha256sum] = "02217c372bec24f32995ff1727d50ed460a6d0b7f8a616abd6cff1c89bf20b49"
