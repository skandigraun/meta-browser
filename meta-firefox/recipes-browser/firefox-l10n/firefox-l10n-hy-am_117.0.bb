# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e649d51ddc1ebb7c3b06394bad99e30c"
SRC_URI[sha256sum] = "1c62edc57a6b423dbaad200cae903302bc091db9787f747a83d2ece1009205da"
