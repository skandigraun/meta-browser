# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85bffe4b14deb96a563cc4b5c16ef683"
SRC_URI[sha256sum] = "950713081e04afc51fddd6b28687db387972f1e22784d2c78d265afb8a96ff0f"
