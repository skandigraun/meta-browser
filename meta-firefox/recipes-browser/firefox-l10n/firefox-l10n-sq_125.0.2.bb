# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e2849451ce3b1bec66e0bed7f43a2b6"
SRC_URI[sha256sum] = "a51416cf363534fdf68631bdbd38daf6b3e4e2020a3f06de753562199d13ffcf"
