# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66230d3fabcd4b75337aabf7b7a59783"
SRC_URI[sha256sum] = "82203dd909a5e82662ee02260454b378d54982850992a4dc6e714f59dfff8548"
