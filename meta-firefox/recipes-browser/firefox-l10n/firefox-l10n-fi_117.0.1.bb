# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb40c98ab70c1171ecdddaddea8cb7b2"
SRC_URI[sha256sum] = "72f028de84e50313449bc9bc4303d23369541d050c2aa1dc1deeb3f9dfd431e6"
