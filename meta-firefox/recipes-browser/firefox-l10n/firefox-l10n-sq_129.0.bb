# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf5d6b217fe30ca40930701c3af19455"
SRC_URI[sha256sum] = "18658f56c68368501e122a4e60bbe411a5fe752f108c4c7740867f78005d278d"
