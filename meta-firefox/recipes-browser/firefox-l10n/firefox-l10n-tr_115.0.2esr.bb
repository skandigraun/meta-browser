# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af380f4b24d435c6ed8844251ef634b1"
SRC_URI[sha256sum] = "ac1a11dd40935ed97b46e256ace5ba8b0dfd0b1f6425e142e3a9f2376dc4f16a"
