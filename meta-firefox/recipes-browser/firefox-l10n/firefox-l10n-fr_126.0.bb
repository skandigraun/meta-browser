# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b51baba8e502ac6f76cb9cf94016bca"
SRC_URI[sha256sum] = "e78385cb50a70cfc12342df9a150a3396ee07450cd023a996fdc5d8639edb38a"
