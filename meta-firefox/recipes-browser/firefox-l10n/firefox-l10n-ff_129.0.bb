# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe270d7e12dd7bce3114a4369bb27eeb"
SRC_URI[sha256sum] = "41b9830e1260ed7577fb8a91d73f8b5ab1e077a76dc030d4791ff257e5afc9c2"
