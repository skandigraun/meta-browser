# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eee0e9a36305fe501c264d2551fe59db"
SRC_URI[sha256sum] = "47e48b26fdd68473b941c43f658d06258ef8fb632bd03223f2d7c0a69a03b8b2"
