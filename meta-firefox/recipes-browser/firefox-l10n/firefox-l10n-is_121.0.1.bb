# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65a2b557065c3373be480883df5ff7f0"
SRC_URI[sha256sum] = "3bb6b919904ef284fe5a6d9ef5595fe64a7b4f88a0b11069d6f2bfe9b17335d8"
