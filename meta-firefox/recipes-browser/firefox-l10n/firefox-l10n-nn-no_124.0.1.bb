# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e6a71ff50e95f99ce208b20679f4932"
SRC_URI[sha256sum] = "4db95a7ecdd525fd73e9bc29490ce03224ffe672d5938728fe29fe64c35fbf7f"
