# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "117cb50020a4288aaa151d58505e771b"
SRC_URI[sha256sum] = "dd5dfe82bc77752d39729dbf02b050f6436d2a5ef7f6101c74549c7eb05a153b"
