# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adfeabcd085d3c415f23cb38da0b5051"
SRC_URI[sha256sum] = "c5712600845caadaf1d09c6cb12e53de2734e130297d4608f4612d7d203c3922"
