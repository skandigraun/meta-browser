# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e7cb25fa87bfc960482f7d5d58ba455"
SRC_URI[sha256sum] = "01886225cb24a3f2811d7211d4d1eb717b47046f822dbbd891f5bed39cea7556"
