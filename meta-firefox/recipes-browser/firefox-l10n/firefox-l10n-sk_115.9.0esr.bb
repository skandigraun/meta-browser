# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cdfb1c76fa2f1cff296ae1e0136a78b"
SRC_URI[sha256sum] = "3142bdf5546de2d58ba7d5efdf8ffd52647d2c71e4d6a5534e70a48aff9bf830"
