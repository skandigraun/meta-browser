# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8de828cbd1e816b609ef4eb8c0fe3a6f"
SRC_URI[sha256sum] = "fd1b2629f9c880a34aa5d58ae6165b1de5413a52e5bdce50fd4e55d3223e8f98"
