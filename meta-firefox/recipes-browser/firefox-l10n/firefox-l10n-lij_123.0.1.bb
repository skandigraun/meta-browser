# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b43f6a5987baa45005b7a68026570880"
SRC_URI[sha256sum] = "f0dcc24e9f5dd37d2fda7a3d927df75c8048be5577323da5fcb6202d9b6b6001"
