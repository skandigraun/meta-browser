# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baba569be62573e30a151f43ddcf0b8d"
SRC_URI[sha256sum] = "533791c112eff540371ec774b2d6709530fee63fa9e0e6d9ba1771af1f1813ff"
