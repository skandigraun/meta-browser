# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fac886dfe649dfd06dba07e9da9ae6d5"
SRC_URI[sha256sum] = "d0c753c5ab171bafdb614a66fb8633901c2c3bbe2c26508735f11fb1bac8a799"
