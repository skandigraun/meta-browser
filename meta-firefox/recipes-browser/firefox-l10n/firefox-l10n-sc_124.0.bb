# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01d30c2b50eba7cd694394bd1c1abee1"
SRC_URI[sha256sum] = "4468a9eb170e6916efdad0a12c1dfd3e471e99dbba80507ff50fa04e4b15a6e6"
