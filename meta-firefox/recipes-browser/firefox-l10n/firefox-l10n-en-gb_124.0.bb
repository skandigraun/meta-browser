# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b1120c3cab239aed00e4a0072cd8c5c"
SRC_URI[sha256sum] = "7f9415249e1edcd8d64f3a8824cb24c0091a900b03b726289767f459b289cc22"
