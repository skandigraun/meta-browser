# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31006fe2cd657071c9d8b47f6cf407b5"
SRC_URI[sha256sum] = "b81fd8053e527763840d8882c37362a3e8e5041758402ee0e5763d30fb3b72c6"
