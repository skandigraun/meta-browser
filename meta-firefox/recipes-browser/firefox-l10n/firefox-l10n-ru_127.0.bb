# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3ca3c4f8cb5c4dc900df6006887059d"
SRC_URI[sha256sum] = "b6105539c4ac39405cf8528899352641e90c18c0fb77bda680b85a6950cf9194"
