# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90cebafe6dd06028387245d381ba2886"
SRC_URI[sha256sum] = "8099358630c52c6fb7a696bbfb99fdd5763dacdf2c5535299a5ac4a7de6fc900"
