# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c18bb927e64573ed67e8ae773c46a0"
SRC_URI[sha256sum] = "d88570556e4a547459ecd1085a6a48fd8bb95d8cdfbf9e29f34720f315387df0"
