# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c63ab6ff550f241f62109cd6ba066f5"
SRC_URI[sha256sum] = "2efb448e38b21a4aa3bccf1f92dc51bb171d5e4fac86b078da35d98e56f32dc3"
