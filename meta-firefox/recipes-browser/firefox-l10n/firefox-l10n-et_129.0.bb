# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd92edee68716edb51d7aadef236b189"
SRC_URI[sha256sum] = "b25f346d9b9441b95e00217e896c2293cb7f3253dff149056f103630569e2e1f"
