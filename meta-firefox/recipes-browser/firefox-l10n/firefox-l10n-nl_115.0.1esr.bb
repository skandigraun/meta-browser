# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeefcf0b6aca7357207844a75b01241f"
SRC_URI[sha256sum] = "eb99683a9c2ec132015b52357cc9e178d8d8f3c3c667ccc7420b1a6bd263c530"
