# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a1a061cac054e7e35f7dca76a3a5ee1"
SRC_URI[sha256sum] = "efd47c47e1c55dade8198e7a6d5d1db96c31c3d4077856709f6f58c30bb59053"
