# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac8c4b8779cf775fbcba942d7a141914"
SRC_URI[sha256sum] = "46891048405ec48c2e2266ebc3b00a4ebaf9888cdbec62c13b6a97ce07e9556c"
