# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e4c9e019ceaa7b8ecafbe74d40f561d"
SRC_URI[sha256sum] = "b717a009bd4087a52a63cda1f464f87ebb93a5db9eef5ef7c19651a1af5707e7"
