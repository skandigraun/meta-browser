# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d8ad9e143b660b140e1d709af9efc03"
SRC_URI[sha256sum] = "43262d6751de7578e747df325ac9e9b24fe7dad8ce7adc78d15bb61e026bf44e"
