# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f3764c482f039ce7fc1ed6c6cf481a7"
SRC_URI[sha256sum] = "b7e88a0602034d8d97914143f750ecc2acf8d6531ce5c5e1711fc96f94cec5f5"
