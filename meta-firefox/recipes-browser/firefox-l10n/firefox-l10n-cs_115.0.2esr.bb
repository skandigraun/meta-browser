# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a463ad3c515f34b7ac84b0edc598f33c"
SRC_URI[sha256sum] = "2439dbb14c36499b93b333d445d9d97eeefd98f28fe1b3d33bcd74ae649eb847"
