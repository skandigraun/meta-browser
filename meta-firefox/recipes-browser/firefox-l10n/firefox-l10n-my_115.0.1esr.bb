# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44aff6794e7acaf16151dfe6b1f85dbc"
SRC_URI[sha256sum] = "6bae75e7508db446d9b6d142f7aedf4f531698b4303005572d23294c37be4092"
