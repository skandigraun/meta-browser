# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e1802376ba993390120ab30d33219eb"
SRC_URI[sha256sum] = "7e9588e2975952308468e35017961f6363c3b78944a26aeb650106bdee081f9e"
