# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58ca0cc15d58547f0f7f114841cafd9a"
SRC_URI[sha256sum] = "fcd829696c2b34f462a4988cd956e6b86a6148dd5040a4c421e809eb4df1d745"
