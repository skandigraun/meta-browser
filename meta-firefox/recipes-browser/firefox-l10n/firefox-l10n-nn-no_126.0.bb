# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "682ea0e5da696c6db5f2ed310bc5fa27"
SRC_URI[sha256sum] = "ec7d825e999b6b8b070e8c13480f88ce044358bead84454ffd7be06bcabfad58"
