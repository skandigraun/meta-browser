# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceebbae08fc51110e62ff4eced1d11d2"
SRC_URI[sha256sum] = "b27589942cc71f7da70af7423dc83cb5106ebe1ac6859a0348149b5b979b96cd"
