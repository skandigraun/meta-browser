# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c002902084c5bd245b779404c063ccc6"
SRC_URI[sha256sum] = "9481d2ec57de52863aab04b6f20ff546e54791f1976e360cfd8d008eace95598"
