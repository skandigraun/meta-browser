# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c4766f4b8c9003b48773b3de2cdc61e"
SRC_URI[sha256sum] = "d4ce062cfdf9bd49c7db4ca456c6cd95d9b90d8072c6d9b807f09e153fc9bc21"
