# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b197618f6b2b5984dc4713b6203b4546"
SRC_URI[sha256sum] = "2ef2ad381738d8ee10b6d875bf0bbd35d659cbcf0894dfbeb268191a21d77333"
