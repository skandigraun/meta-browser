# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d9f742b560d12f21a657c6d0f516e82"
SRC_URI[sha256sum] = "48ed75947e866c05e8cf208a7c5dee6f6ca99f8943654661896f3a2f3ccd8706"
