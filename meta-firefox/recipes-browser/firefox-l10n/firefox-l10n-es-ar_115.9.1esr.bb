# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f864fbcff56892b85a88deca5139b298"
SRC_URI[sha256sum] = "80e7ec9f078d7f2f2d81781699c281baf4e150030321cdc22c100bb807454b6a"
