# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccec2552a39265c9828983b7bbe6d82b"
SRC_URI[sha256sum] = "6adfd2d6f9667472b0665f0370c2eb582355ca370ea046028741b91c16aa76b2"
