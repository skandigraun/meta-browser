# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5edf36fe2e4f5657594b2811cb6785a"
SRC_URI[sha256sum] = "d4db148b690f4b892f1f85dce958c7c904a64c1446638b082c9d7670fb5f6da4"
