# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac868f20fa2324bbf91bfcc44eff048b"
SRC_URI[sha256sum] = "81cf5af388c90933758b27ecb2c07efa65760c0443c2b74c8fc42c6d90ad5ed0"
