# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95de88add4202653eaa6a01b48cccd06"
SRC_URI[sha256sum] = "3ec4f56272551a3b45530058a51ce633dc3eac11bbd5100491dc97cadc18af0c"
