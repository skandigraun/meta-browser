# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d79893ce480ee103fcc54ce8de84c14d"
SRC_URI[sha256sum] = "fd5021481f8fc881e57d4486bc253ec58981c43d814d99160be426f883c490ac"
