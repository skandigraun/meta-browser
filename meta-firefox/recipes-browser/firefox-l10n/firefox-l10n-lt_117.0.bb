# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b389f690dea5b416a84830119ce7d9f3"
SRC_URI[sha256sum] = "d4a5de8ca9a62bfdfc2ce661d9a6742a7d00943605e671bffe9ef6505bb1844c"
