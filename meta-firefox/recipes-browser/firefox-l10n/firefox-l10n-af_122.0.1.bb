# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "841833090011604519eb82d70960decb"
SRC_URI[sha256sum] = "805055af891b085917ea7ffc4a205a5359ee205505793adb9cb0a1c8f7a34404"
