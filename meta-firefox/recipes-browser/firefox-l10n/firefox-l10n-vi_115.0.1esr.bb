# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d7a8b27ac79c5704c3dd76191d7e51a"
SRC_URI[sha256sum] = "4302ccafcc33089da244a92b0f6363a1e0a1f0937f6cb557d223023fd4845b3f"
