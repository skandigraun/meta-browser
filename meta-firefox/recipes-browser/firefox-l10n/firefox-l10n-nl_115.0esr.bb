# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2b357a09bded298efc0962e3a5de6af"
SRC_URI[sha256sum] = "e1e7cd18b8425b8c2ca01948ca99496d6af819b20d3348ae008e1c125c0af153"
