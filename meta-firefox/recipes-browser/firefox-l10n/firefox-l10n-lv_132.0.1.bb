# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afa73a14f72565df9d38a48201015dd5"
SRC_URI[sha256sum] = "7a908caf947fbb8547771c18581d91b2e839fe1603f8041e8419ec403f4fac87"
