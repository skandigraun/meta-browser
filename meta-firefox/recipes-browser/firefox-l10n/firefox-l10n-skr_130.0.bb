# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c97e4f5d31fd7a8169408c6e1b9c56b"
SRC_URI[sha256sum] = "582e29550ff48182986fc0b7fca248de6f3d6ada8bddd513cdd882b2b9a517a7"
