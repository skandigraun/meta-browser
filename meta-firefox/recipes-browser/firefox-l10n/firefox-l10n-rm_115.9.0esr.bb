# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d11b9ade934cde0a8608c5aa49eef1a0"
SRC_URI[sha256sum] = "12428b3af157bc91beb303e4350c80501a432b20f70d09928d4b935c207b98c4"
