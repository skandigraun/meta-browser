# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7a34a013ef02eef9d802d8e0efc9b6"
SRC_URI[sha256sum] = "2a902744218c854732af470739ef4dd1d1932a26e179ef4acbc4235c2ef10863"
