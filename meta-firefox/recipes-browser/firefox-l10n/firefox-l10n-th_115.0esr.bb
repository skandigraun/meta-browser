# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf20a01db4d0eb8ed4db799dfc127103"
SRC_URI[sha256sum] = "f3bd574fce02d2f9666f85c5f83d1d09c406cc22703fe2662e7d6417c308034f"
