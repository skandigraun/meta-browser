# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c273da18559d4e2faf28c8d0a733d0"
SRC_URI[sha256sum] = "6e6aa4d96d9eaf6b4d00440e7035fe98ae0d2bb402e7d6e1a2506f11b63e2fc8"
