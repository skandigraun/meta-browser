# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f05a7e51b381cf08f97401941baaffc0"
SRC_URI[sha256sum] = "94ea2993b6a8c0d6742d58524c091c9f162cf2b33afc1a7465d564f4cf176d5b"
