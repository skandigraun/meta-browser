# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97f65619c0170b0d248c74a176e4ef62"
SRC_URI[sha256sum] = "c2f74d3f9d44a36894e65c2e8f399aa44220bb399ba4f32c1a92e3f10a3a70f4"
