# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef3f1b1f879650c2be0f690b43c68f87"
SRC_URI[sha256sum] = "d6cb9c3a5d631c7c4c57968c12e4d32e27e404fdf42b60f840e68322e9eed039"
