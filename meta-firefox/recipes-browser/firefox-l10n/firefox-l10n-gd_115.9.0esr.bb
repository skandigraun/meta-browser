# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c1a0b9dbbc21289f34d6bed402707ce"
SRC_URI[sha256sum] = "fb6e3b2b19bb0d99316a45153b5842ffcd7c7e75210547d52b7f6202f48512dd"
