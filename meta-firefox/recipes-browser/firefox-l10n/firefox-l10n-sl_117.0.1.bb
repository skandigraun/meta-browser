# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8848f30eafcf7d6ece4cfe3f3516f50d"
SRC_URI[sha256sum] = "e790f7fe15f884a31483336b0cf9276300625a63d7c34bdad25abc3221277a01"
