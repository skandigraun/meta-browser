# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "190042f4a77c80f5b3ef34132fb69094"
SRC_URI[sha256sum] = "baf9563a2b3427349c73760a47f3adb228f1e9e1923b11bbcda1a5447cc0d83f"
