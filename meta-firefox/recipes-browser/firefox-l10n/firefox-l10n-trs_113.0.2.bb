# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d78cd85d995f8b95fe51618506fa621"
SRC_URI[sha256sum] = "a34c52a282bff5032d17edbafd678660019a053f8ba059326fccfbde2077eb4e"
