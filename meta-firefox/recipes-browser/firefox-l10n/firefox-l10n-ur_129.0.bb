# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ae4902458dc9235f4472143098e9593"
SRC_URI[sha256sum] = "5f0d29614bc140590556d4b4f3c7a1f3e9ae5deaa4d8943ee334c063bca0a89d"
