# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e9b4e03327096a98d7c53fc7be99529"
SRC_URI[sha256sum] = "b20abc1fa1d7d88fc5e05e5d25aa43e0ae29b00b66ce988c80220395f3c85de4"
