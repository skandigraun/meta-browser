# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e59935847e57977732e52b08b41570e8"
SRC_URI[sha256sum] = "8710117095119ac4e61247b7d62ea4669703a6ca143766bd8f19fd619a125b9b"
