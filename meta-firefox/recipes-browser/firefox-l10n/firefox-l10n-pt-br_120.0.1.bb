# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96e4e9a755a05cca38fe334c843a1cd1"
SRC_URI[sha256sum] = "7039916f1381d5d09d8527bb2c59a24aa17a170c0bec4038ffbc2f1a84438dca"
