# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1527582ebf32a5de0647909872ac2c3"
SRC_URI[sha256sum] = "37a355160860fde2e7e522d1d4bf9287b6e7aad125f4bb1e67a76c6885bdaa3a"
