# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc5e235697c75c67c515c5336883430d"
SRC_URI[sha256sum] = "b182729567d952fd88803dca65a72af0b1c326e94adb2fa8b698ae45e3e4c8e4"
