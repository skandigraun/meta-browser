# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36a15008a45eb641d4e0a972c6016dcd"
SRC_URI[sha256sum] = "12260eca9195228b572a51a30e3591efd4765fe39e0031f553d9e751dab33088"
