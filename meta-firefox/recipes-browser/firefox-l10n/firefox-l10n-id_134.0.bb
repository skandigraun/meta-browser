# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c45d45e35291e980f0a1e0520ec3e9b1"
SRC_URI[sha256sum] = "3ff420dc5ed935cca418a2dc51210b406bcd76f198b4cf2a72d7aa0cac81777e"
