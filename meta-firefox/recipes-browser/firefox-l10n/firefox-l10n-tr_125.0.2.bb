# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6e8fdc59ee7afe16b779636e253fd27"
SRC_URI[sha256sum] = "9a4f9b6ab160636c734408b0adcdb770620be81921d8e34289cc5dc676ebba58"
