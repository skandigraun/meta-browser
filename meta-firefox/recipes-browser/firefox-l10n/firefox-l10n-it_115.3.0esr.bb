# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1661d4da623a7b82e6ad719217022de2"
SRC_URI[sha256sum] = "a2fcceb0f3bdf47104b0fce91cb284fbb37680f514277410274ba8da606b3383"
