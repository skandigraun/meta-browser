# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "073ac888a284812088debb4013357332"
SRC_URI[sha256sum] = "4ab238de63d17ad36dcdbe2274a2812b0721dc8bf7c0d1b3ca1639de40676f83"
