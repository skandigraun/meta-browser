# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c030683be7be135d945934e6e5d65204"
SRC_URI[sha256sum] = "1cb6c6e188eeaf3cb60cebee4c0b40a3c6531340dcac70ced86516fa072dd0e1"
