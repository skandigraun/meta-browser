# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "add354c2aa691242c5ec4f2237d60553"
SRC_URI[sha256sum] = "fd3fd5585e91d1c64631ae2251f8dff968a146cc58593c8e7de51bdefd130b6c"
