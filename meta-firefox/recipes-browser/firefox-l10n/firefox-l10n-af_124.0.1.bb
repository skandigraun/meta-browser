# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "703d7f4d899b25be93975c2cfe8bb689"
SRC_URI[sha256sum] = "5020dc349ce7753da2fac2cec6348d84e7a5bf89ee7f5a51c35c69ffe4f56c83"
