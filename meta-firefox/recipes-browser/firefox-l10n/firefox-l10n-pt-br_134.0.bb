# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f49d347982da703dbea65780782a1880"
SRC_URI[sha256sum] = "61630880de9b09ef0845400575f4622352492ca09197cfd86ffda6666cb09222"
