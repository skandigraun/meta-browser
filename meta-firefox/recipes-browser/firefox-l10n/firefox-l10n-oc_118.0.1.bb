# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a90572b1c4d771da5913a02534e9727c"
SRC_URI[sha256sum] = "e87cad82318e39a1b8838a21b5daf346ef4d60e5b679ff054ea84878d7f76840"
