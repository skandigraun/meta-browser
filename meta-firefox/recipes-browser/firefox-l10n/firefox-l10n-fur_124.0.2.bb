# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2519d76085f2a3650c0fbb7c955cc9b4"
SRC_URI[sha256sum] = "719888fce454acb3a173d31e0cdcb356ecb101e18c9c45150cb8e6c11a597c92"
