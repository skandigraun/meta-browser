# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78e54a23d1cad0d80c57d9fe8fe80a7a"
SRC_URI[sha256sum] = "0bb3a7d1f9c88f1f0859516c2fc5bcc056f4d405ccc4dd3c649deb740188d102"
