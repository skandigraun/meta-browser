# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cbf29c8fec8f046b17653de7139813c"
SRC_URI[sha256sum] = "565f2db43e5720ebd7672ffa4451467996d4ce42eb7cacc0c486d8e7024f39eb"
