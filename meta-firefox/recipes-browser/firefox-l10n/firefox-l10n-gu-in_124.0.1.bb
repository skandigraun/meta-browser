# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd73140c939badbfb4c7bdb163a37fb2"
SRC_URI[sha256sum] = "b03c2dbf68239a5bf50298ae779275ed66c452436314be0a2db5a96cc204023f"
