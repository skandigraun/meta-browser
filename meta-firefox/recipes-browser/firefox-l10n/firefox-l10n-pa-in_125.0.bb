# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "343fc2abbb7af9bb315a4b71710e09c9"
SRC_URI[sha256sum] = "f436597aa35d95ad39b57ba3cd0d9a971037e2295cb4a6b561b1d8bbb08d0446"
