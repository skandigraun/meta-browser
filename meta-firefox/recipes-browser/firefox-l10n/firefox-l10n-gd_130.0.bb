# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "955abed66c1fad37384e3f7837002989"
SRC_URI[sha256sum] = "129f408c4ac1fb3821b8d996e570de99a3ce81adaf174280c1138d4f00b6c8b1"
