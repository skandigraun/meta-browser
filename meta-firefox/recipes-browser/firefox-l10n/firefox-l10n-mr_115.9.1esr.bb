# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d5f8aff03fe25adfb7f3b662dfd409a"
SRC_URI[sha256sum] = "7e4c752dda9fb1cc312483a2ad07c35ce32432c5b7e0faca86a8ef9bd855c7a1"
