# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f3a6e013a79d63c71e1f9f9bb98a4c3"
SRC_URI[sha256sum] = "759ee4764e4627a7448025cbb0bc68250bc4c586078193b4a8ca370605dddd7b"
