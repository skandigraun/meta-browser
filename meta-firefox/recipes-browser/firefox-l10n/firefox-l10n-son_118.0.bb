# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "663682c05ea4fa1cf3f8c8d69349cb4f"
SRC_URI[sha256sum] = "8422b0628af49eecaed6e4bc037410423f13fe05ccfbfa3d647000a89c389424"
