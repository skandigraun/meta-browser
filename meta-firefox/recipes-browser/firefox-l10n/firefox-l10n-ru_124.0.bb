# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bb7886c70adbbef32c9a93786a008df"
SRC_URI[sha256sum] = "eb6e67b2e1bb974b5858d593d8116aa74e87e1dec60a6f75bd0dbdb8a73ddacd"
