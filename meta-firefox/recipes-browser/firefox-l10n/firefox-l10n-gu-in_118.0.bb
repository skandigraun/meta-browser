# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b3673e321ff896d78921ec6765473c6"
SRC_URI[sha256sum] = "b903cc88cceb6f262d7fde61d203d6903749dbf65e3eeada7ebb3a6106ab0fe0"
