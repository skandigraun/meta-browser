# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c1db0d61dc0990fe63cafb6650877b1"
SRC_URI[sha256sum] = "eda2649f69344170a01ecd9205e5680fc0193d8a2811a7824bee40d723faff5a"
