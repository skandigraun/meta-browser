# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1690bb8ac09b155746a80435ef376df1"
SRC_URI[sha256sum] = "fe40046f7ddd431902969d223a6bdc8b97ab241af7b4bc1f86761d763b1fc0b2"
