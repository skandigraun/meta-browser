# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6370206e449ca44e61c09b71c6c90b4b"
SRC_URI[sha256sum] = "92cc1ab32c281621df47e0e977356796cf7c9c26374d1b943b810d0b7a7a74c5"
