# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6632ffd220b86dfb93a9a585ed948ab"
SRC_URI[sha256sum] = "987345af5409c80f91e40525840a7068407ac9beaf728488ded1ab5afa33f8aa"
