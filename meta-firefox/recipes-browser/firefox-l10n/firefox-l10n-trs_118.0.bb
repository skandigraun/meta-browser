# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d6068088fa7ad5b1d78d3f2a0bdf372"
SRC_URI[sha256sum] = "6de1a89754d4a3f75d6b6b69ee8ee4716c0a616e0aee989fb7ea6cfefaa37578"
