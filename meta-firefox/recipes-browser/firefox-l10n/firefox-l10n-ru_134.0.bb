# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d611bc5e47feb7ef0abf9f8a3e7de1f"
SRC_URI[sha256sum] = "cd204b1a240e0653cb11ba5469f9128065c76a870072c6faac3200b0827adc78"
