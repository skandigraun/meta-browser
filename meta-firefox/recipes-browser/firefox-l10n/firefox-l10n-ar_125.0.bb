# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca197118af735745f6679bb1992079a6"
SRC_URI[sha256sum] = "5e7f237de5dc1080c24fe3771d5bc0abe6f8f348e18e3721b72a58ac6e5ff2c7"
