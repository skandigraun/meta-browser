# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08c58c8d1ab1d2892b247da5ec046814"
SRC_URI[sha256sum] = "2f589e9dbf2b9ae53be6659df7e141a757d723a045e4c30f9647c2e5aaebeeec"
