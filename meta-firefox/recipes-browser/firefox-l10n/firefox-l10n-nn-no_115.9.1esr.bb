# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6cdffc008102b2e585e68ce036d178d"
SRC_URI[sha256sum] = "eaa81877817d213815099dd2fb89cb785070ae4b085dcf2127d552470ccc824f"
