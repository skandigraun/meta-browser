# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfa327c4f76bcd09e3a214889be8e507"
SRC_URI[sha256sum] = "40539606c5a356fd448c4fcfc197222d69a3cd99ccd70110f274db079fbfed8d"
