# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bb49834e0c15528e44357ec32c06581"
SRC_URI[sha256sum] = "5a6ac8f8e3715a78b7a8a65c708bebeee41a86b372e83077fddeae7015382d3c"
