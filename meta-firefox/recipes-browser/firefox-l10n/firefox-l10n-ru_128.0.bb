# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0c0bb1705efcf787db2b06adcc2e63a"
SRC_URI[sha256sum] = "fec019340841a2b6953d14792ef7a9b1d763f150bb758827ed63833ad0bf2165"
