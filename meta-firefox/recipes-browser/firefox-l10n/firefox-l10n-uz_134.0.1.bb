# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb5c77da33bde5fa175d910ab4d4acd2"
SRC_URI[sha256sum] = "5e6867fea66a14a56c3dedb82dceb67425c1c5b9f31689e02911a446e746e7ee"
