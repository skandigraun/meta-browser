# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74d265cff9a2290130b28d397d834305"
SRC_URI[sha256sum] = "873654b2ebada3cba49fb3c56c2ca68fbd6d9738fd83b59de6170c0bced57860"
