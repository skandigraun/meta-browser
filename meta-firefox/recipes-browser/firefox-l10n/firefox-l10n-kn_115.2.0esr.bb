# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3767e6506cb778687b7b1362910b154"
SRC_URI[sha256sum] = "d989a636da5c8fe6ff3c48c13720bc1b53ec32885271f281817e1e73c5ac96a2"
