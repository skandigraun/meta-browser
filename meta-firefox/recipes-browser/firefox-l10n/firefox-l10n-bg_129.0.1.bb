# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6845cb788b2187a7ea3b27b5fffc1617"
SRC_URI[sha256sum] = "1e454ef0fc813685e7c21ff1e6310b8580837c5719797f50bd47a1d3ddacc18e"
