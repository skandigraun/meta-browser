# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f4ce3ea62456b1d5a60a8f7a3d412d"
SRC_URI[sha256sum] = "8a7df86f57926db4cdc7a6b53660a0bf89d239805f3367cee27d423a449acccd"
