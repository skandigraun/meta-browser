# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b902f84f711934c86ec3290fa913b53e"
SRC_URI[sha256sum] = "57fe89e6efc8df46fc17213923f80a1eca5cea4b5f92d566ba7154b6f439950f"
