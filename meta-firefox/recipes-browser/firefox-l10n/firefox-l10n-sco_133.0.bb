# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c583c0195ef33cae5b3605874b961ce8"
SRC_URI[sha256sum] = "1b669d23fccabf1315e59bee6fe5e9f68d97693c71eb2015c5283e6af8619b02"
