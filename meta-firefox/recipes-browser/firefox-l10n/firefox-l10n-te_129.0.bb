# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a13c584cc979752d69a52bc361f2ff25"
SRC_URI[sha256sum] = "b072a5eff79adc78c117a0c5189f78219b7b4c6a6e133ef1d934ba76f554894b"
