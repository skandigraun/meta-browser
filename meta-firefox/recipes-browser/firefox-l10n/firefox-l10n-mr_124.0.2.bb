# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f5b5dbb6712afde1f1368bbb2ffa14c"
SRC_URI[sha256sum] = "a208506661a4e20132ab29492720dd9acbf8ff5ec8f7fb20d0e6f841471315a2"
