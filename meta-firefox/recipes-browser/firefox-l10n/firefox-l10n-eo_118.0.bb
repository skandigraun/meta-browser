# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9db3f1402788344a0fd1a7fdc060ff13"
SRC_URI[sha256sum] = "dabcb9ee45c85bb7a8013125cba3df9d90de4cf16cc912af70b1d20062290dd6"
