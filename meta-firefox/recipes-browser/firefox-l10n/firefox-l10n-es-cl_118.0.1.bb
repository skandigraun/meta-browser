# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0975c75ad49eeb23848f994fdfce07bf"
SRC_URI[sha256sum] = "02f0be74a93f2663fe1c1caeff7007d7cd34eb1897fe07724bb08b3b431f76a6"
