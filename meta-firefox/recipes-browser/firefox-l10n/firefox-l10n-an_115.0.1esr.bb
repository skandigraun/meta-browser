# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aa74fdc7e52bd8ae777a09716300e3d"
SRC_URI[sha256sum] = "f692bf3911d5d54f22e0173d771dbac6e4abaaab18f3579b109f9d4c9fa7b797"
