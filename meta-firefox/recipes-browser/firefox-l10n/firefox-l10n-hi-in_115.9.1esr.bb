# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7788875ad8001c0c47dc26defe9e970c"
SRC_URI[sha256sum] = "a65408172f0522451e364ed02b74b9b272deb9dc3cf202158acb2e71ce0c8ae2"
