# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cc88d8b7252df93df3e4c328eb57314"
SRC_URI[sha256sum] = "508f6eb1fbb462d2b1ceea59d53465e089208bc3d0a755a27963e2a1617e7a56"
