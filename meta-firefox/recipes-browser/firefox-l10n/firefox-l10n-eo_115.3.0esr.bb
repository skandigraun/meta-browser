# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9bf9a9e4c6a2a8c3efd0b8fa62b96d1"
SRC_URI[sha256sum] = "51ad5fd1599a1baed51f47061c38911be399a420c73483b4b94411944d974ded"
