# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3971ef51a58307bc3da2d53e6aeac34"
SRC_URI[sha256sum] = "e4a9fac40c67c1307eb9f3fd561c5c3a79d8c234ef0f4e77b563b907bcd51830"
