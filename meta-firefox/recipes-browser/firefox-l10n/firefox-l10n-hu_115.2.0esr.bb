# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed564acad1763598da60014336e0b2b7"
SRC_URI[sha256sum] = "31a4b7d5f011cc8d1ec0a44eb1c1ec59f4c57c558ac7b670a750707afa8b9adf"
