# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3776ca2d830d94c8d8ae6e754827039a"
SRC_URI[sha256sum] = "797686f4f8ad9279e8b080ba39cf52f049235ff4ce6e61ca0fe65f9d479a2d45"
