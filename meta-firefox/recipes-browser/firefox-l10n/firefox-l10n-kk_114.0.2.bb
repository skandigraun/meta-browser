# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "352ed9aec46b8fb6473d3fc987169ca1"
SRC_URI[sha256sum] = "d83e25d8dce1d1968b16202b3f36affdaabcf696af46272095521002fec68056"
