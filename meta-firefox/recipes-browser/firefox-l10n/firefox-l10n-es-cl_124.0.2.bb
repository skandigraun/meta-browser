# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3070470fda4a4095ae9dde7f19f138b6"
SRC_URI[sha256sum] = "8ca6788654ba0562bc3c4a60d42df7c2560fb5ee0e3085b1c28db635af059452"
