# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d525bbd40fb49d2ad3fc2a5959d237fb"
SRC_URI[sha256sum] = "fcf58cc316b3392fa131417dca9fe81c6a9694200c27bee1ef19dadd4e7b6d8b"
