# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfff3e2def04645c8565241ea63dc928"
SRC_URI[sha256sum] = "a83a689c165c08110b03d13c3c53d217d330400cb846e25b2ec999ba863c1e2a"
