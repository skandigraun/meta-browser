# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "980a4b9bb73d608b371c58728a8df352"
SRC_URI[sha256sum] = "14e65c1bc9d56cac9c485545cd3ceb7b42f290aab7fb1f928cf58ba240732fd2"
