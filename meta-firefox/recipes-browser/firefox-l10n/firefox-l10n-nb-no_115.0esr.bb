# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "333224d89df9170d6c96cd27cf539928"
SRC_URI[sha256sum] = "51bb9c6e7354392a3fdc0d3c4e2ff2a3c44af989d2028bbc6c907432b4fa5ba2"
