# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a59575a06d3bae5b9695d78db272da39"
SRC_URI[sha256sum] = "47d6cb358508c59df7be5ef2da5149c5a4cc5dc234dcea3f422099e520fc4206"
