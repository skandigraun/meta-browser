# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c9cd786534a3177eb057c306052cbeb"
SRC_URI[sha256sum] = "cd1c558cba6e4f5f32fc1af75f9f65e2df3022afd7a7f2ad82cbb453327d6996"
