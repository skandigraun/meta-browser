# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df2859cd18f24059716b4255d60317fd"
SRC_URI[sha256sum] = "24eb5e72b5530ed1c0d6a7b97b00e72caf5ca35fb73a9d216d2cc4b81409d983"
