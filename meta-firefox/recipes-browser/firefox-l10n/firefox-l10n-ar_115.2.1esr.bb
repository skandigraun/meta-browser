# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "430569d114cf0f5c12658b95ddde75f9"
SRC_URI[sha256sum] = "43af7e94fdc5b17186ada6fd908dd522c3bc51562af08106ffae2e45a2b3be76"
