# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5cc691e573fa3512bce3530e7e10827"
SRC_URI[sha256sum] = "b9fcbc9063278b77c652ed738913c1d9506306796af41c42fbe5ff2bae721fe1"
