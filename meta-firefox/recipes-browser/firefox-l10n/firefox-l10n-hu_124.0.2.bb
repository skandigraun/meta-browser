# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9895bb37b8521e848cf3563f3bfc01c9"
SRC_URI[sha256sum] = "f601d15f457fd72f0642e060f2f1f34a73141a0d7f07de96020e5b8554a20e5c"
