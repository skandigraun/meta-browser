# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bd2e454bc241e0989d8dab1941cc8b9"
SRC_URI[sha256sum] = "ce0040da0b13095478d3340bd471a1180d8c99d4e2097a46b4bba8134fefcb22"
