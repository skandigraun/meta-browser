# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22445e14e32552cd1c63bc8f757517ca"
SRC_URI[sha256sum] = "032beca277e96aca1a7d5d0005029b0f2a86a5f8c05550ba1a7a4e764d9d78e7"
