# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5fe0047eaec71ad50c979e079a85215"
SRC_URI[sha256sum] = "9ec2500ca866f0e98d324d0f999a71fb565e6587761ab8e0fa7ad7249cbc381f"
