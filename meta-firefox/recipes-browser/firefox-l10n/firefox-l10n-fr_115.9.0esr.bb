# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5294f57f92bd17cd5543184d3b677d0f"
SRC_URI[sha256sum] = "c2fed04499dfbf952c57831441fa3fadef5642d48d57edc1ffd0d42176dac686"
