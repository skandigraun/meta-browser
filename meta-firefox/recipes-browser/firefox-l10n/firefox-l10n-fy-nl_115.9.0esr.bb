# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "589b05d594cc3812f93daa809a7341c2"
SRC_URI[sha256sum] = "d43abbb83cb3aa534f3eca329b3c929e426b3edaf46e4fb217d4e3f49ec13561"
