# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94a7a14f1a7a376de01e89f91db25497"
SRC_URI[sha256sum] = "db66e7fdde11118c776bb4cbf29754133e07b622fa5ad5f31c2776302353a88e"
