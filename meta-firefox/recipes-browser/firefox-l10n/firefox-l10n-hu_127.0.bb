# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24b34ff2f2cf567fe57f99fe8988ca6d"
SRC_URI[sha256sum] = "6aaf64c7c594616a3d91975e66232ab4ecdad7a3dfe73995edf2519b01af7e9d"
