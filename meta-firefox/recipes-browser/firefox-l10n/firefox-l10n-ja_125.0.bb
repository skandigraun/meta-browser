# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bab9bb6432a4c30c20739fff3d922185"
SRC_URI[sha256sum] = "d2d740f61fe97557f0bd9b8c50e9171f316527d23ab427a4a87b614e2cfddfff"
