# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6418112a9397198582bfe9a7cfb1560c"
SRC_URI[sha256sum] = "ffdf9b241d72ce949375e9d117d482297c2e06466d93b6d4d55c50531e1086e0"
