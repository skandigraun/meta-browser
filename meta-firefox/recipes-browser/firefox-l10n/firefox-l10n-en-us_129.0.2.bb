# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69f5f7ea0349c38b6b6497c720b4288c"
SRC_URI[sha256sum] = "9a8eb34c4f261fbd6a81c3e98acd18f356a6bdc6ce8c5248456c3d8f1a08174e"
