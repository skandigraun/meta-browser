# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "514bea3d2d709efc901da4f00aa18a06"
SRC_URI[sha256sum] = "68656e7f66dbfb2bf9e92056bd7a283567f81ae7f232bf9481d85d1710a945ab"
