# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e72e10ed47cef335f5eb1e18acce6273"
SRC_URI[sha256sum] = "53f6927369a29b44da2da3e642501850f0a3ea26a7de6eead620a7ae38561452"
