# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "052ad21fc4793eae845f19c2e9eb5f41"
SRC_URI[sha256sum] = "b1c7d920c1fe99f0be76c6037c8ad9634ef6789d8e884c17f879a663b67a497d"
