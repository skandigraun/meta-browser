# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7450c8aeafeaf41263b56cea5a49876d"
SRC_URI[sha256sum] = "91724f692363d279c5314eba6371b584cd2b59ea47742327503fd04adedbde84"
