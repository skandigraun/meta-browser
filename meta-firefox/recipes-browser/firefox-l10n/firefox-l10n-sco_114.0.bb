# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "677c1cc1eac7def5d23c995d182a9362"
SRC_URI[sha256sum] = "abaa5588c5691a98d7d8523e8c3923586e8d5d3bbcfd53535b8c089cc308e14d"
