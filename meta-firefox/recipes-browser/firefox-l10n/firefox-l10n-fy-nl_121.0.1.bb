# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df4e1bf93f996aec9f04a85023324f41"
SRC_URI[sha256sum] = "613cd3f361e5e5aab47c1b3b2f41a12c265885e29001b4607079d918be7e46df"
