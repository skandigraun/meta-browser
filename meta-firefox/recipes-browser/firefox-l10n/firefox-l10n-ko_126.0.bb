# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51920cb5452aa8205440e07db90dfac0"
SRC_URI[sha256sum] = "462efb256ef18ad8e1d6bbc40dee80807f426d9904435e9372671dce0c7b5eed"
