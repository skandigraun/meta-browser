# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27644e04c21033b19de89b53b3b636bd"
SRC_URI[sha256sum] = "0ed3f1c0cfc8fdacc642938f581c0984d8c1623fa17cac674c7f57c02ff78476"
