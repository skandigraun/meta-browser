# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eea5326022ea4f6f5a61db975451210d"
SRC_URI[sha256sum] = "6ca2dff93076d338f44b715cec7defe7416e7cedd17e2ef8bcd092df767fb81e"
