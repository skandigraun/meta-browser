# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "780255389966cb8ad023707a7e8c8873"
SRC_URI[sha256sum] = "29a0efa1e64cc1fbda495b71d3ad222d986288667c9786e4b0be45db5c021b37"
