# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "962849d696c3551927a8057a5dbfa6a1"
SRC_URI[sha256sum] = "8b7a8964341a20d18ee37c2591ad755f53c90d7d049a20c1a00258b476ecc5d1"
