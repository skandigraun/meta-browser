# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a55c12ef950e69f30681c0cb8f48ffa"
SRC_URI[sha256sum] = "76bf2feee2ec45c909b3f25dfbb3bda937bb531353978d201a510948a37ceb8e"
