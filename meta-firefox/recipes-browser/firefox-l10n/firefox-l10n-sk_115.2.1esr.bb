# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bae39038df5934ea915db0215b8928f4"
SRC_URI[sha256sum] = "ada8d1fe2d5c3ef4fad5bb5f68f54e37c96f1d7f8a6acee8cf32e6f2e0933e31"
