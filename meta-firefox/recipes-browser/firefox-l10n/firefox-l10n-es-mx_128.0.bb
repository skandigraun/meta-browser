# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb516c29c7be0fed8b6cf9120f08c035"
SRC_URI[sha256sum] = "3741dd7afc678af6c0d987d563fdf482ff92e0543c6907e4cff0d1ead578a6a5"
