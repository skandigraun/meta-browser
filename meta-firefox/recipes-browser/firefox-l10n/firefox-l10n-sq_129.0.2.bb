# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdaa9ef31838ff25d98ef26de52726af"
SRC_URI[sha256sum] = "c783d03c40e0a9837e073115e1e561f904dadf43568c1237b2fdcd953fd5d589"
