# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "170576fb133f5744387c838909186597"
SRC_URI[sha256sum] = "fe6d5560ed8f54c0e6988318318cf0a79424a1935adc3dc0e3c1c885eaedcf29"
