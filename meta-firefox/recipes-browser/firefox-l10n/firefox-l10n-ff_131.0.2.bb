# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f15762553bdd1f730145c0a50537b620"
SRC_URI[sha256sum] = "7b82b0d4f81a613a015c2fe5e12f7c88650fc18256192b376444f9d45355fa82"
