# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd87715de229662003e4e5ded3d2130e"
SRC_URI[sha256sum] = "4b1d7ae69ef816d3b66a37db856d62323c9867e53811968092f21e5d5029fcc2"
