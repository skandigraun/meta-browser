# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "892e2132c2a586bc8250fac5dab72346"
SRC_URI[sha256sum] = "0b1e841c34dbcda5f2f22a6f5470c1284e1ca8165c37e57ddc497d70baeaeb84"
