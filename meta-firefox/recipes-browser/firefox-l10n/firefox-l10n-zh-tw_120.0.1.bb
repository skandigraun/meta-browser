# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43f910bee106313073193d4dc04e6d8a"
SRC_URI[sha256sum] = "9a2828845d075b67dc4263cddab963fca4ddc0584f7590ae79a3123ba1442655"
