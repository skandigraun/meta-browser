# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3209e34661e899fe2f5895c88c4cd1b1"
SRC_URI[sha256sum] = "b777e55395dc111d3775337ea7ad24d46a4f7bda89b6733a7d6ccc7334aff671"
