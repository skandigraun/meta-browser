# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de6b9e9ed8e3d557541706f1928d2e8c"
SRC_URI[sha256sum] = "2819ab11df60b7703a2b3641f510c152a68b015c576791e2d52ca43d285d7ac0"
