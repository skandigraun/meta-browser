# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddf97988619e47d2c23242a4e2bf8ce3"
SRC_URI[sha256sum] = "701d56ae16cb13a2877353287e18bde1595449183d00036fc9d7460971114a39"
