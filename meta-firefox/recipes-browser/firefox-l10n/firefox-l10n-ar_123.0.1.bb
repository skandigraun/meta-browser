# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c938e94f1a929acf3a10973048f9644"
SRC_URI[sha256sum] = "667446a5c292d937c5be3f95812a5984eb8444d62570177f7f8f041f7b753e51"
