# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53aaddd887fedef0fece233391c674c9"
SRC_URI[sha256sum] = "e485d19a7b3a6b937da384fdcfe8c5c038241fcdbcbfb29fdf422a895d535307"
