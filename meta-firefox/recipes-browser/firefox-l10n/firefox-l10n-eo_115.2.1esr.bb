# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a291f6d1771e1c85f11d15318657cc2"
SRC_URI[sha256sum] = "e7f542d4c6bbc6766c2d64e33e99cbbf4109f090626fb54f5644f7aac2835c77"
