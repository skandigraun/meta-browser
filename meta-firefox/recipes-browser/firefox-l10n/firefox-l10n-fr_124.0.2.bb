# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79efe50792a7089a4094e74fe73b51d4"
SRC_URI[sha256sum] = "a5e12a9bcaef2e46e12984a48a177901f8d82604e66d3a19e512a29ac0f08f1d"
