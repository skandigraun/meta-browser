# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d08b1c3c749eef64fa0551b6aca082a2"
SRC_URI[sha256sum] = "05a7fedcd75e62e43422e938e5162e233f02b454f5232ce43d2afd47bb808fa0"
