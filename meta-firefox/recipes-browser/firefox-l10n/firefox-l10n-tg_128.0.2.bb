# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed530c2f67808f1de46ccf38508c5b29"
SRC_URI[sha256sum] = "aa7452ab1f591539ed00ae120bce51cc12c32b66a1aa0e0fa27f730999210b5a"
