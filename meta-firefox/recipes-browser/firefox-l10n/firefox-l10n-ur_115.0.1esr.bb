# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20aa8602b625fef2d92c51d261efcb59"
SRC_URI[sha256sum] = "79d55d8f3c1df35336fd7bf016d208d9f4221b9871289fedcde75e168cd5b703"
