# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0edc7d041e5742bd684ea0e606f47b01"
SRC_URI[sha256sum] = "f3bec565c0c4c1bd7b659e4c4922d2d33ed5ebc1dd81e9d7b5a23c510da325a0"
