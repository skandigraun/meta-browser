# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5271945e8c0614eb42aa2a58267e39f"
SRC_URI[sha256sum] = "8efd13f3e39d543636fd1055adf903c6fa0adc95ff59835a2aa3c91728686f28"
