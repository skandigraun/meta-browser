# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e359d5edd4cd1d544d529f222790ba9"
SRC_URI[sha256sum] = "f5049f7d4c22a7815f21fcaf7037d7a059ac76b257a812d9c8290a77679ac97b"
