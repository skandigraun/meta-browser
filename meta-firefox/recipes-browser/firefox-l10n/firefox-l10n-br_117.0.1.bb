# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38aae17ce3f6f4605d65d60fc88dbbbb"
SRC_URI[sha256sum] = "b6f7453f2c276695b51501f8135363d2e672e8eda4a6cbeaa4a4b091b329eefb"
