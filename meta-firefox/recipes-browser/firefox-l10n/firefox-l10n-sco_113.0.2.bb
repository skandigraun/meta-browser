# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fa060f052efa522918918eb7c4c883f"
SRC_URI[sha256sum] = "e6c2da802a83c536718cec70616b899c56e649935383d8e2b848b5cd2545e251"
