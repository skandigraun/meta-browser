# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54948b8bdbb2850b689391af8cb6f5cf"
SRC_URI[sha256sum] = "5399acc8a30259b11ed4c773534ada255364569518b8486130bd7e4636b700ca"
