# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87a53b267907c2dcccc83135a4a5823f"
SRC_URI[sha256sum] = "a3acb545e742e9dfb0d6423d658d3e00b60f1723f24eb41c9764efb792831826"
