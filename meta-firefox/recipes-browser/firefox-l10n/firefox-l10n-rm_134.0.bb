# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c7abd3dcd3f826ed9b884a52945b6c"
SRC_URI[sha256sum] = "5bcd0870b0c8bbc6dee1f7cc3f84132a94bc1e197ded176da7e1ec48613cd5c7"
