# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40be275c15f356fdff6acd596478508e"
SRC_URI[sha256sum] = "63d54f27e3437ffe4e6431c783120ed1eedaa96e119ceb1328725634b0199618"
