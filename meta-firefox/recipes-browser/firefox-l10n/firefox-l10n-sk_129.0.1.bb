# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59277bc474ee9ff88209923d44f01b88"
SRC_URI[sha256sum] = "bf9d6858de5141ebacafafc1bc1d5bcef0e6ae501d6caee39bcdb8e77b35b637"
