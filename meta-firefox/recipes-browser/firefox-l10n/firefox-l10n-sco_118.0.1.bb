# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1088ab495e2e25a08f989a1783998f6b"
SRC_URI[sha256sum] = "fead12080650e08c747673214e130bf49089f1ba7f8e342daae386511f8b8f7c"
