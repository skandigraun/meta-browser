# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b276b27c37e971e6ed956599b59914"
SRC_URI[sha256sum] = "740777b57ace2591070d76c32143d216f6ea5c6a994a06cf86ee9562c66b5840"
