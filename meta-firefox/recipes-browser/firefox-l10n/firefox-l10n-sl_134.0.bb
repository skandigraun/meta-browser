# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "927d933ef7beb1fba2694290f6ddb228"
SRC_URI[sha256sum] = "e34834734ba5bf5a97e1d3aeb7cd9699fd6cb1ad7cc07ee6f8e8425f66ca2f07"
