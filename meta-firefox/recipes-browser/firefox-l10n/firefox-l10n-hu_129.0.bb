# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3b91560cdf32a50c6f249518a40057e"
SRC_URI[sha256sum] = "f1ebd5edf6069191e2dd5b5ba77cd200f8b1997e904ec654e2eee978b2a33373"
