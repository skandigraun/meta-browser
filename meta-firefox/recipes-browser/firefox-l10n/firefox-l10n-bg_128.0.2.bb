# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc172d1bab56656e373bb41eb7d0112a"
SRC_URI[sha256sum] = "5b61ab909065ef07c1e06c09789a8189b8adfe910ae8dca183cf2c22df8cc19c"
