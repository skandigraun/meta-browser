# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9ab1240a24de370c1bb5ef143f154fe"
SRC_URI[sha256sum] = "65d2a34a6bb17708f7cc76b3d11141c85b586a0515bcb2220b116c9c10375ea5"
