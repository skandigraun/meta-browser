# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4bef6728d68d920ebd011a7c6558c16"
SRC_URI[sha256sum] = "172f2e6588d49eb467410815218065eeb9ef60b7fb2902c3c0af57a75a3f8c50"
