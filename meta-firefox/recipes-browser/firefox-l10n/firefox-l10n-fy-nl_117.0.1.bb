# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9c984f94816c12df6aa442caa946f4e"
SRC_URI[sha256sum] = "ec8fed4ec2fcf5871634c493b8511126bd4537f18c6eb03937a7c236c32dd3c3"
