# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8426ed90535f4450a95f3e8c046c7315"
SRC_URI[sha256sum] = "6029a936e8e17288b9b2f761a17deb957f18aee882c3fb5c47d42f1b7f4e3415"
