# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1056dd35fc3d72d4ad5fe7399ddd4f5"
SRC_URI[sha256sum] = "2b5a08727af0575f5b6399227433873e686ec0eee8a447ceb57ced5281e64002"
