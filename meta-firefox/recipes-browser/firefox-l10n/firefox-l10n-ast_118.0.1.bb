# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bd26033e6c1df5f0c26b8b0871d6c40"
SRC_URI[sha256sum] = "a53f0ab787d65ccefa52c78974df00fa75c0a68a99c2fdd87a53a4facc147290"
