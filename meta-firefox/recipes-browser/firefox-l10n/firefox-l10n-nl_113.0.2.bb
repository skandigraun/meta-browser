# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d12e35d971cf902554fff145b42ba01d"
SRC_URI[sha256sum] = "c35aebf13f65ed920917bfd70c0ce873d33b85cd9ef2d0ab9f2a02debc1608aa"
