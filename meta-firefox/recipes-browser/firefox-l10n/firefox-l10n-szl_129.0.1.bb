# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8b433f7f91e662b287d8be2f034fb37"
SRC_URI[sha256sum] = "bd41a3f4b6c2122a48ce052d18b2e5b93b37407b9c48d1b049a758cb72cb47c8"
