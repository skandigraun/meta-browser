# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "302b1b6b59fde0dce3205db51ce7385a"
SRC_URI[sha256sum] = "0a283a8bffd8152d021fc783288186c9c05ea38d816f1729f005bbe856089117"
