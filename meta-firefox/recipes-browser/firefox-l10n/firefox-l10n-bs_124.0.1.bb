# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc281110059d108256f7195e5cbc2ac0"
SRC_URI[sha256sum] = "0c7e4069bb2de6ad3b49d2d9a6d8ac15c2ab355bcdda66c0c497ad0073dbf338"
