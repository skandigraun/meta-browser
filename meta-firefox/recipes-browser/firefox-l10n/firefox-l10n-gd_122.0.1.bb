# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b575bc419e83e9f8fd70304bee10ebf5"
SRC_URI[sha256sum] = "3bcde2dd48e34b79b32e4ad34bfc41b87d02e7e1241139db5d99768a469c0d36"
