# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c4e064f36c58b54a213dbc0f2ffad15"
SRC_URI[sha256sum] = "686c767f3b253fd6c45a2861a4f82e86762bcd1c04d5bb9aff313a33d0d0882c"
