# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8365a180ab48736e51f3cf451aac00fe"
SRC_URI[sha256sum] = "f0944ae225ae0a17ce32d20147b00b8dfc7b588fcd22b6e61a2356cbf2095045"
