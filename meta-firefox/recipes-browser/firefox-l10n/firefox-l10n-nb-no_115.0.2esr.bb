# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b56f662b36b9d55f04f910e41468f07e"
SRC_URI[sha256sum] = "c5cb7b9c19be0a87616bba0e67689369f84158d61e26a10e14a793aa552a8cce"
