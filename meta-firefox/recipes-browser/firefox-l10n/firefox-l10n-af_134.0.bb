# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb7305f21261caa74f3e6c9bae99d75e"
SRC_URI[sha256sum] = "63f2071743478164bff06cac4916a0e33c56fce1927a9575bab6c4a0f6ba1e4d"
