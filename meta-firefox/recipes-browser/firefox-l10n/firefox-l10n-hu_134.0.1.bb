# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "469ad4dc3f3701c2c74a17a468cf40ad"
SRC_URI[sha256sum] = "d109e972542ddee84a74ab4ea9884b85e061cdd9f292da5fc0ad2e79ae83987b"
