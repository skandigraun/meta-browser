# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e75f9c1b22da81a34b85b065fbb6cc4"
SRC_URI[sha256sum] = "e01cf73a874e3ab6cb131e2b7ac1877c9c716f13b059701efabc76546522e594"
