# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6961f396d6aeb89e6467fafed2f0903"
SRC_URI[sha256sum] = "560731186b050f4c921034ea4e398dbc36ff2cacd136f2844c802e6072a2705d"
