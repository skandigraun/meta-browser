# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "424fd1032b6ae35c0d3eadce83a81b55"
SRC_URI[sha256sum] = "475e0e77515228dd1e0ccee9760faec1fb1d8f68cc36060fdeaf35553739dcba"
