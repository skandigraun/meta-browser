# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03d7c827760246b8844c36386a2fc467"
SRC_URI[sha256sum] = "53e5c8a5287be68cc8eda21830a18628eecedfe7a47f58abbf457bd09109d9e3"
