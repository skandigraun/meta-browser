# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c8b200b627e6f8df4cfbe42f7c71e8a"
SRC_URI[sha256sum] = "279c4d92ba43045bd5d45c475ec4b7d174a108ffdb7f9c614a6c724a712c64a3"
