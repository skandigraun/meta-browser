# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cfa63062f02877c9b861b0da436ec36"
SRC_URI[sha256sum] = "1be3fc070a1a6f77e736d41fa794ce2d1dd22ca5c53df0db62a7e6340de337f5"
