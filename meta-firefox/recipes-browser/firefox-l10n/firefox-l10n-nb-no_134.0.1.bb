# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "154a009b7ef4bc050bbe2510b2af418a"
SRC_URI[sha256sum] = "d72ed95cb19c2e7a7e9d3cbf608f219bd2bff0ecc879a3b229840242290cb25a"
