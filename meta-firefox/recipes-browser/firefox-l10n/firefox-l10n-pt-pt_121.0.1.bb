# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "708459d430736edeb621457e49f86e6c"
SRC_URI[sha256sum] = "cc1fff36f8f294fe98a1afdb948ca125a0e676ee0ff146eb0936883d68059593"
