# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71183af89839ac30bf9b42803aabfc31"
SRC_URI[sha256sum] = "d5482ed6a653700e15eba6706f1dafcb5e0348358a8c21f1618886dee8236c5d"
