# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f84d744dc75e5861af59e861ebb49d6"
SRC_URI[sha256sum] = "ff239bdcb54a03dad3210b9457231e56a38e306220ec981c1f29307d73620fa4"
