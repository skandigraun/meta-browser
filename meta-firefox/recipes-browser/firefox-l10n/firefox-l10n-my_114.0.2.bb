# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f8698833c635bd1e1b370c83eb605b7"
SRC_URI[sha256sum] = "3c3ee587dd29db160ec584a129a7edeb817bcb7bf6eb7eaacb1de3b48178db8a"
