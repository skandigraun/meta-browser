# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "391bc9ee990bc92397d09222d51b87c2"
SRC_URI[sha256sum] = "a6999bb22d81cee4cc75e296b9d4e252d58f71878a5660f453b7e9c31832c527"
