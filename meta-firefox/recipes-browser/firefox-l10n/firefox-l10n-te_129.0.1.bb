# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07c6a974701f1adf0d052ca9d0f981f1"
SRC_URI[sha256sum] = "66bb9d29a97b3a8b65da13f0acf760c4af7c72b53b3adf0afe8d904bff8f3912"
