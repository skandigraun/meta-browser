# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10e8696053765fae061281e2b9bf6bd0"
SRC_URI[sha256sum] = "28f334b929b04243f3a48e895572b4b18b40dcacc0495c1b5b51f3d9dc6a0370"
