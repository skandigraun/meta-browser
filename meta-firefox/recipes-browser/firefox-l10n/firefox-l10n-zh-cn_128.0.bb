# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d9cbbd20322a17ab94311db8ce7c330"
SRC_URI[sha256sum] = "80803ebb4aa08cb6249afab49ba61d43a1d31ed982732c1560c5947f9cd0ef0b"
