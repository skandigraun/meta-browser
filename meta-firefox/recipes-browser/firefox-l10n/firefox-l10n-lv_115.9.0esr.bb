# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04dc4f7915c5896c7aa8189966198087"
SRC_URI[sha256sum] = "8f3f30b688ce23133cacaa2c013ea2334655a65b77a91faa284c5d22c0be84e1"
