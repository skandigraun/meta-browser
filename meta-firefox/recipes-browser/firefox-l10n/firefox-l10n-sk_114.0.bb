# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018cbfc2382de75df7a034a7d145409e"
SRC_URI[sha256sum] = "86436adc98e9f449ca2dcdf076042987400d62f8acf9458abf7cd98c327751e8"
