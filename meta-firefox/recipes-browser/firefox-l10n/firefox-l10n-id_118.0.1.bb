# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02916c13465aa50bb0ff89344e502e2d"
SRC_URI[sha256sum] = "d5c2b265132b7fab01aa57841c927480fe5e20b001b51c454de4ee5488d4d277"
