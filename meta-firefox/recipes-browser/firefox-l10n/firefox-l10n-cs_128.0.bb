# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab9f20b17ef973d3850800854ac03b5e"
SRC_URI[sha256sum] = "052caad3e82190c6879898c4b5946f7209019b2e8897746b1e1415c23c482e96"
