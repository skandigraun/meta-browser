# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "798363ec3bb4cef66aebaf75f85abedf"
SRC_URI[sha256sum] = "09a282879f05acc015dde63a8715dc72e407cd0c7fba30b90ed187ecb3661aac"
