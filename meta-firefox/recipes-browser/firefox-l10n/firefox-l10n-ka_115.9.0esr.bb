# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aecc1403cc1dcb41c5bd6948f6fd9e4"
SRC_URI[sha256sum] = "cf8500089ca3b2e7826ddd7593c3f53dafd4057b32d34c56636cff23ed4abdef"
