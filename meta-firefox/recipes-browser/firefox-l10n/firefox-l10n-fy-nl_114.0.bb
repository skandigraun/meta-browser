# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "687d4efc672822dff3f5f406863fe46c"
SRC_URI[sha256sum] = "c2c27f1b46fdf4288fd04ff8554443542ce6821cdb7c13e3ddc7bf51c4b62c0a"
