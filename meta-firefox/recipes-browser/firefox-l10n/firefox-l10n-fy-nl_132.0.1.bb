# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b5ca917b04e4f052733ccd8443e4e17"
SRC_URI[sha256sum] = "bc07183b0dbf1ff9724ccc6254565968948fe6c418c84b52bfd82fe99dc90779"
