# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d79a440545156ddbb2b3d79a8a7043a"
SRC_URI[sha256sum] = "d8e462b24cb0497df80c0b95239851eb91e01e78c725cb2208f04dc5d57ab34d"
