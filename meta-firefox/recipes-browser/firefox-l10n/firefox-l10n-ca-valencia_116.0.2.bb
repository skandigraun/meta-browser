# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5278868242c0ace4a2ac44be896f685e"
SRC_URI[sha256sum] = "4d6810bfa7503591226c69a55a1f22cb9c720368b6cbae3ba4d2971e137040e7"
