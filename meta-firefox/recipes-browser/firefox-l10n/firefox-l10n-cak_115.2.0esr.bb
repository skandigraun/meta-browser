# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5527fdaac97a2ab1f9f9ce132203082"
SRC_URI[sha256sum] = "19a8df331ff42b1801e394f46be605f5ce77a4483c28d5e1f050b8230f9b5dc3"
