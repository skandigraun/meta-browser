# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e92fafe65e185ae9f004378e8c0e9e44"
SRC_URI[sha256sum] = "858ee8eeed9f53cebe03ae70e78172b8d44f266bdaed84984749d5be71627933"
