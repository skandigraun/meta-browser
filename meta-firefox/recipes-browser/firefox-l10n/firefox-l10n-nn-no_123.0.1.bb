# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c6ee30324ba0223d3abbad093769378"
SRC_URI[sha256sum] = "f80a04d23a9cca44781a594fac2ea82adf6c13eeab34732a7b61a946d6416426"
