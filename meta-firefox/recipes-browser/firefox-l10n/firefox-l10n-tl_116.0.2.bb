# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b432c058b135714f024307b9b16d872c"
SRC_URI[sha256sum] = "71f30b8538bfef9ebfe678211edeb3f535a8c7c0583cff58580cbb799d131ce2"
