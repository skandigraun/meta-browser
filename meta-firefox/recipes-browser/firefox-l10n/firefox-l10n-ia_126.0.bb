# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7595ad724b6a5dfdd289f5e59b0044d1"
SRC_URI[sha256sum] = "e353eada9a803c78ba5d2cc293c38db274b2c5c812afb9642e51804f3cfe9a67"
