# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26e6b86e5441bc71ced6be37375d8650"
SRC_URI[sha256sum] = "de83ea1e4adb5e0a6c26af0117ceaff554c02f311055efccf24cec9aec9aefcf"
