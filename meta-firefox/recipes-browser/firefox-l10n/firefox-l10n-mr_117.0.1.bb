# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad125aed8fd9ebb18f9e623c965472e5"
SRC_URI[sha256sum] = "273e97f97425466557d8a0fc76264c61898790e78dcecafd75173e329c769033"
