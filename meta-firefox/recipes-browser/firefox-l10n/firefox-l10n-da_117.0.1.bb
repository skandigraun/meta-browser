# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66e8178e61b7b21912963efebe2e89b7"
SRC_URI[sha256sum] = "2f3bdef55733d1c30e84a4f872b15c22a14400e40e998609c9088533c04505e4"
