# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "840e3b28c26ef5e12510bea415f6aca2"
SRC_URI[sha256sum] = "3ab7bd34f0b9a3043dbf51382a8f973f6f1e6e4df40124b7943b1dd7cef43735"
