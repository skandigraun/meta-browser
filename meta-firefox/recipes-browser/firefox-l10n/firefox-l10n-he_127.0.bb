# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f68f5dbf68d984261b60c13da629a380"
SRC_URI[sha256sum] = "6d3a982dd34b46ad1a92e9c49e46b8d1959795a92826ce0b4f274acce72c6801"
