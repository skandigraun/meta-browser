# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d19c821d4b18201bd0321c792b2889c2"
SRC_URI[sha256sum] = "0ca2856c3b5e2082a5bcd96c149b9737da991af7e3fd442f020269581fd1a2af"
