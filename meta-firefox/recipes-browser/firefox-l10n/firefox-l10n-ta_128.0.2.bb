# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e1a2ec6ed378725005a465c31c4ee56"
SRC_URI[sha256sum] = "be40752024b4bf389335d4a5f1f73e36c8dd30ac3f5517d84c6ced33bbd7a8bd"
