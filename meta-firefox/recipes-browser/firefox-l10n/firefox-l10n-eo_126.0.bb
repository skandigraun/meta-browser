# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9589fc9a984d80ad5e7d7b2677c3b931"
SRC_URI[sha256sum] = "6741265e7611d4871ab79d0eb761fd10792d7825a1ea0e18c58975e14ecdb0de"
