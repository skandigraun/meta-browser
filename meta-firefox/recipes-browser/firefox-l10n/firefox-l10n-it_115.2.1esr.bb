# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd9dbe752a0083a4ad3cc37e7dedf7e4"
SRC_URI[sha256sum] = "708eb834cc8e5ad852c1098573932b4bc90937dceb885525d68a187285c4c2c0"
