# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1508ddf31f51b1c5c343022ff98a5fdf"
SRC_URI[sha256sum] = "345944ffd47fce1bb7bdd4fdab75bb1a8907b6570465144181f3e7b3eae357a6"
