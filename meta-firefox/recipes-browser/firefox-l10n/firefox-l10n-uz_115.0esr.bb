# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3552acd8706251d115f228ff99c938b2"
SRC_URI[sha256sum] = "3c29309eb7311d4d3563675370433b08c4ba42d4cbb76556dd4984713c825b1b"
