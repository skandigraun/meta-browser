# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0201cbe8b6db35cadb2fa7b70c2e305b"
SRC_URI[sha256sum] = "347d70bd11cc38375faef7f6355f08112535156a9184072b992323a39edd7db6"
