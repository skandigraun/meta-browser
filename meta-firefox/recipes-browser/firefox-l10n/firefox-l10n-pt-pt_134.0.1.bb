# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f696c7aaee3dd09b9190feffdd870d79"
SRC_URI[sha256sum] = "4eca2e18e5e30d965a98eac44a7b50f09c5f542083451f8ff15f965c022bfda0"
