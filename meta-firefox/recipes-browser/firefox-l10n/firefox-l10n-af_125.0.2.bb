# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e384e9f5d468b1e7402e5a11b317270d"
SRC_URI[sha256sum] = "39f289252e6850b20b211cf37b8c99bcd3db9c09abc44c1cf2412c65f8e84250"
