# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "479189ae22c5231d0525fa2ca302adf6"
SRC_URI[sha256sum] = "f861e955b02e298b4b8171e40c65e1f694e8749fed4bf0409e3591acd18914c2"
