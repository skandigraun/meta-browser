# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9db98805d23e238e70cafac3b82bd970"
SRC_URI[sha256sum] = "94f7a5e9eb40c7817b3ef1dfaf90c517c1faf64a6d70b0529a047294b20f100e"
