# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "621634228ee9783ac7c108919665ef3f"
SRC_URI[sha256sum] = "6087236de7c01761c8aa9e44c37210fa62b8b29d23442d0f438c5731777951fd"
