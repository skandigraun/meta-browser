# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dddc8788a16faffb17a4267f987b3f9b"
SRC_URI[sha256sum] = "7b721eda92da240981b056bc7b8965b21d42165cd3f96ff7af3cb45f2ce5d74c"
