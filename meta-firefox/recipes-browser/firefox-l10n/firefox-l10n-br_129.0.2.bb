# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0151ca5a30477a9d6c33796342f5539"
SRC_URI[sha256sum] = "d1ac7b81548c51b88fb89e45fb2cb92a6f767439f51a7e05a4eb11dc749060e0"
