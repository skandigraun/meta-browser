# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51c12eb7eaa14625c454759e09c3a0ca"
SRC_URI[sha256sum] = "8e145c5ba908d15a3fe258395453f5d086f5cc0a68b31b721487bdbe3b5afe76"
