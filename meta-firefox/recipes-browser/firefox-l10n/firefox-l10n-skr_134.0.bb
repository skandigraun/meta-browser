# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b13d21ebe3e7bd8b52235fc70e0970"
SRC_URI[sha256sum] = "7037c105459905a43cc6b792c8f75afc6a178ef15be6df18a33711fb0858e91e"
