# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "953ebd075cda86bcd44fb747bff834cd"
SRC_URI[sha256sum] = "857868b45274b003131bc13cd6cb3c272480b94d5bc07ccb23e37ccb458c58a0"
