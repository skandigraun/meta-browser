# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "904c353d2bdb31b6b90acc754cc9ba4c"
SRC_URI[sha256sum] = "31411d6edd66cfcc9399a3e578dbcde62f1fbb3c9162d48c95773b9f4a669ef4"
