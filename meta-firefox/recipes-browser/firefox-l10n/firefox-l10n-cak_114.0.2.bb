# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "557d88c8ff0ac67660b7cf024ba20cea"
SRC_URI[sha256sum] = "b7c086ccd272a9ebc64de3f9d29fa9c2f700a9ab3b4e73ac7c04dd8dadaefe02"
