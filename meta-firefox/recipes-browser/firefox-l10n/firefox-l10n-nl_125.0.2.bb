# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89ec73348dae42e2d0037415cd62ec47"
SRC_URI[sha256sum] = "6aa84c592fe3a2b13d7bb34348c28c426057950e9a12688aebdfc923e745ba35"
