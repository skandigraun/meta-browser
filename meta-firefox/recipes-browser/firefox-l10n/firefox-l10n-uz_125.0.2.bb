# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7638f21ec3a84590ce96e4a76e13acd7"
SRC_URI[sha256sum] = "f3ce5e013272ea8bd75d8d1282f606e78ade1620492da5316315e802f4c8f853"
