# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20a9dbc7986892636afb289f6c28b1a8"
SRC_URI[sha256sum] = "abbbcbd822118abaf942f42ed6ee582fe6ac166e53e6886747afcef58235bcdf"
