# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d34e7b2f2b07c3bcd3906added6c62bc"
SRC_URI[sha256sum] = "8f218ba5f7d5c032988aa8dc21a621e9faa62f2a711578ac8d5d6a643a530f0d"
