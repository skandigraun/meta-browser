# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "777fa71821086fe70c848031e7c3adf4"
SRC_URI[sha256sum] = "b277465ee323ef63bc6ba244262f3f1e74f57173ac21334597cdb3a46f003a9d"
