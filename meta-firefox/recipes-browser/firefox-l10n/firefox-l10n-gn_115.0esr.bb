# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84ba8fb1c49c6e4553a377a07731e0e5"
SRC_URI[sha256sum] = "828c17b691829ce25487771411c19634e91d0c643d84fc8cc51e8fa9485f9688"
