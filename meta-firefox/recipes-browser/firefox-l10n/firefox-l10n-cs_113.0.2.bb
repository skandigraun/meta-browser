# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfc92c5c1b27c6ae5146b80d431116d3"
SRC_URI[sha256sum] = "e97d665ad7df960c9d435f497aafb52144fc83f1d173078bffe3e1e15879a716"
