# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c35f119ee5d0be6b8e1d19ea1cf73c1e"
SRC_URI[sha256sum] = "7e7c19d9af13a43ddb12992d773b734f04ebdcefe9b899318b0c2b9928c2f487"
