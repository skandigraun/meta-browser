# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "213a3f7b0ca4394e9c7257796b4c2298"
SRC_URI[sha256sum] = "a7b82aaa654c5c290eea8a1ea1a734e79b2a3ecd782531a1df83d570c2bdae9f"
