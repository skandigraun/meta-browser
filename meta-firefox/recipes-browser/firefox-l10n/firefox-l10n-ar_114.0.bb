# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54d9ac89ad040e238c2cf826cc7615b1"
SRC_URI[sha256sum] = "4f6b16a79b454c72f8fdc0e4800e7a085c392a3204cf2173fb85853568820fe9"
