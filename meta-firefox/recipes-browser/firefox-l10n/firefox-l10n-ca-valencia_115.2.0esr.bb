# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "885fc18ecc523376ad8136b3d51520b5"
SRC_URI[sha256sum] = "621fda5e4c38080b05c85b69de480f408d61ddcaf5c2dbb5ffc7331a171725cf"
