# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66dea5b86a08dfa81ae0200c69849b6e"
SRC_URI[sha256sum] = "28a41ee387a617e51d4718b51a62d73d32e1c61dfdc39344b5886548d91c92a4"
