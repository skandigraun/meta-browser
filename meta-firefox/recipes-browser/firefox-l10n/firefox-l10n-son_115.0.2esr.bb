# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6f7247b1470725e039d2a098a07a415"
SRC_URI[sha256sum] = "69717f16e4feed3cef5e3121900421daeeab8b4466721fcdafdc5bb88b6fb474"
