# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce8b91eea01bd6d43679202a371661cb"
SRC_URI[sha256sum] = "0d2b987d369fab7360bb74c8665d5df858ad79e48a79d58106c1ca6a3886dd15"
