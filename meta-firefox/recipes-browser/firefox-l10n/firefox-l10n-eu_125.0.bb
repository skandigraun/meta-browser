# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "965933b33927b38764c0f82a05b9e79c"
SRC_URI[sha256sum] = "9ad102703681d2bb822f105682c2bfb73a9302c742fbc3c28d51b5a27d181292"
