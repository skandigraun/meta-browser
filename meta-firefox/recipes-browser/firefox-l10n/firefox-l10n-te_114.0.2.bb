# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e592547f6a2fc1a091ce79d1895e8a"
SRC_URI[sha256sum] = "5d038c29cfa150814cfe8dae20aa287431dbe07c774902aee5a8c2c9b0a0dbfe"
