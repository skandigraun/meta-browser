# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb3d95ff28c6b166d55ffdeee92f15b8"
SRC_URI[sha256sum] = "e141cce7a226c7b3bc11f23b2de924f4a467cbd7ab71d6400e8d5dd2cd88f260"
