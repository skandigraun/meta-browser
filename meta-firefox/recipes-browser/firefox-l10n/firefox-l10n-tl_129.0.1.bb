# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f87c4ef9949ecd2d09c909fa6d054e5"
SRC_URI[sha256sum] = "c436ac84dc2f86680c41474265ebca183359f570c6eaf96ffc94f39ad17edc63"
