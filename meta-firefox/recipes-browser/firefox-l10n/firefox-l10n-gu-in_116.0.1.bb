# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09a3104939ef79a9351dc260118d8032"
SRC_URI[sha256sum] = "0b1280e151970c9060fae366cbfcccb3e034ffa877e3bd026fd7cc4709221177"
