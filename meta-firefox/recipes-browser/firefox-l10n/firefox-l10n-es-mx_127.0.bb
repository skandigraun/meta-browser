# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c753d8af7a2cad6739c88dad946cb5c"
SRC_URI[sha256sum] = "c3e7fdacbb2c1d5d4693377a9c74f99b5df55ae2e2fd0f07d8f9bacb595351a4"
