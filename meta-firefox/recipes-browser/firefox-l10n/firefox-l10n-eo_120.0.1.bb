# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a1fe6e59f4afe0f06f2a108b1c135cf"
SRC_URI[sha256sum] = "d2ce2e22b13c354974308f419ea18c1950a056b4a9b06c69b08644bd5fc32364"
