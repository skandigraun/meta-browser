# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce60e2c8a28eb24724382e172946524a"
SRC_URI[sha256sum] = "d6cabd878f53d864caf6c1b88f766cb64512d731318d6bb5e31dfd3910c3c456"
