# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cec60429f60776647afaacb4dac0d58e"
SRC_URI[sha256sum] = "15d4203fb4b2fd6f7f22bda9aa56c4f2fd1f606ea037618ff9a3a5408114d6b0"
