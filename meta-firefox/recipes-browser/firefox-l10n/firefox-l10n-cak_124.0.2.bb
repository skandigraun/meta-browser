# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb90fb81fc0db0261e8d32f76b75acf1"
SRC_URI[sha256sum] = "47359caa8cd76bc6fc75f8d86fb5d935d09e9e9123c14a21c194bd44c44dcc22"
