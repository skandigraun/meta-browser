# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd8f460d4c37490823f85d8d7a63843d"
SRC_URI[sha256sum] = "25144b58250a49ee753d0e2e558641d5431fe098eaca2fd59aa60e29a1ee473a"
