# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02247708dda15fcf6a1d3e313c824dff"
SRC_URI[sha256sum] = "d55bb16f2f9d6295c490bf360b11f8551dea8b56b4df879eefeee8349d670921"
