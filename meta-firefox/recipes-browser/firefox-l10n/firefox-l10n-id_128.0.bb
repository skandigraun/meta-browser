# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d294e8b661394c380a9e61af9a82a6b"
SRC_URI[sha256sum] = "106f6a40382cd00ff9186e3b79cb38fb5a9acd94a96e95efc9e681c83616e809"
