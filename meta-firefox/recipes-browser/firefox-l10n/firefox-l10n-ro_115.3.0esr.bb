# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4843eba843c9558bcb9cc828af7b6c6e"
SRC_URI[sha256sum] = "7b431fb742baad667b5d5069dfa955c81a85d4ee4c77f7587f012790fb3e65ab"
