# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2405933a6534ee8ce8711ff5a94baf40"
SRC_URI[sha256sum] = "d394af95d114f79f54d1dd369a492a10920da05d28a6181b4b17631dd5da7ac6"
