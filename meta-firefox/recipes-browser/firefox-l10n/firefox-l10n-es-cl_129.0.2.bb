# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fd6969e68f87530c1b873efdd0ad1f"
SRC_URI[sha256sum] = "d6bcdd929b5d161edb783cc53ab00a16516053b859540514b0d2851f500b265d"
