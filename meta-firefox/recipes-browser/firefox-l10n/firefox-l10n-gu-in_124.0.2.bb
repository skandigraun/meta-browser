# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29f4a70f18fde4f57c1162ab0b875b2c"
SRC_URI[sha256sum] = "9e2c7eb26fabb157b69c7e77d58445cbd1d56f82001e3e6140438034367446dd"
