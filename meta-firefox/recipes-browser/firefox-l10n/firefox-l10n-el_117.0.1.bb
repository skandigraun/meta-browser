# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df0ec2728e56464d7fb04d5e2395f92f"
SRC_URI[sha256sum] = "05225e87df48dc80d9f1ae59681050ba4646eb61fd54ac2c1d3b5b63a5b9b2de"
