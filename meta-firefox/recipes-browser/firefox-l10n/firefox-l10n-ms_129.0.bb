# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a569962b87e6ef87430c89a6db99887d"
SRC_URI[sha256sum] = "ad9fe7fe55a1e0a3588fb7a8d767698b6f7b45c911720bc03f3bf1048ea8144c"
