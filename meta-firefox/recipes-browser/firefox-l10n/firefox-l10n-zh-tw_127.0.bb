# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d01bdd12507dfcfeb9efb0eb0e7204ce"
SRC_URI[sha256sum] = "8e55c9f7bb2de3dbdb4295328e97adfe1c6d8fc7b84b70ecaa004a3da33a6129"
