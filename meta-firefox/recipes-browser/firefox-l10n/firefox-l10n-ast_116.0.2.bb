# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef543af44a0bb15c49a73badcde2e42d"
SRC_URI[sha256sum] = "f482aed7f2f3e03b7129ccdc549ef201a5c4ef764076c3d0970de2f8c3cf37ce"
