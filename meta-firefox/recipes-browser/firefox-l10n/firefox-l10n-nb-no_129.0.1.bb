# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13de77e6be6260092b3dfb7ded936020"
SRC_URI[sha256sum] = "a16d7875a197aa4088a1072e64d054add491e0f5e2ccf6caf9fb7f647b981f89"
