# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cf47bf4fd14418964d2e6c707ab30fa"
SRC_URI[sha256sum] = "1bff9e2761b2f4dddae792b505b3179cfc249f09aa74f5318feb0ce9eb87ac60"
