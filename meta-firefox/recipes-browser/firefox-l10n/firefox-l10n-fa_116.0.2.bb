# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b96a7e363d47fd96f4e5e3247bc4be1e"
SRC_URI[sha256sum] = "cf519b5b35fccac19b9451d8c946066ec1a55162e0571e48e241ad38f40acb5e"
