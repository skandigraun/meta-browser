# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0599f0e15bcc356e060f1f58bf14afa0"
SRC_URI[sha256sum] = "6c61b4193c604c24793a5c5da54999f95ade557b732121bba263dd683cd3b7df"
