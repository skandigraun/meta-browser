# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0151535381847dc30f834f50419aae28"
SRC_URI[sha256sum] = "36c58a011459a217ec6e3179957af5687f8a42864f8177fdc6c838ee9d3c5a0d"
