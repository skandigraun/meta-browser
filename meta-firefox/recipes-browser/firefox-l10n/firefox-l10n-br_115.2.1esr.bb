# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f7a910f050ea183c768caaac80ff505"
SRC_URI[sha256sum] = "09eb1b2c71d2d211f3fb61d66d4b514def7c32798cbfa135abb4163e572d3e43"
