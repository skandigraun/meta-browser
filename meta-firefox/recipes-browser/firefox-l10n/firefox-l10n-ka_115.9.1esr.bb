# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ab6f6c07a40bc3592e4ee1f69f49b40"
SRC_URI[sha256sum] = "2f99b8e67b5a1be3910ee8ef064c01c21924aeebfdc3e6a53dd3082f3628d2bf"
