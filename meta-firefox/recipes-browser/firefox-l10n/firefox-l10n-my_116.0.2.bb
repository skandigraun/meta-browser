# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07a21ba282fc1e6520f2cae44af6ce08"
SRC_URI[sha256sum] = "25a5f0529ad47b70405908a268f0c1322b2a084b433cc3cbd549b660a5a3e3da"
