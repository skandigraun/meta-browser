# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb81de4d1973ff9e8883e9741819db60"
SRC_URI[sha256sum] = "032e606f24ccf9933c4932b5f3b60867b16df4d3d252dec89ace1a9ca969cb77"
