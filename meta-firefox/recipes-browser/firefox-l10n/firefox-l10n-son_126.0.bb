# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "027aa630202750854a9932dd6fa6d9d9"
SRC_URI[sha256sum] = "0a657da8f013deba1fb9430aa1ad668be1d6c14cd1fe3a38863f756b1dace507"
