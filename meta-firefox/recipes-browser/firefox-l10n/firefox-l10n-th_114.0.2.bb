# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "844f967c31e5660f7f214365e0be8cc9"
SRC_URI[sha256sum] = "bea977835a64333b08279c51b6d9e07d5026b67c5f1483275b92292a7a787c39"
