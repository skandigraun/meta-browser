# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc8b947b86e4195cc858d1d2fddb2b5e"
SRC_URI[sha256sum] = "94eb41fc132d4377ad90ab858a8edbd8ce5400edf1be3338a4133b8f7e025f13"
