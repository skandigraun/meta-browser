# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2751d477a080e501733af723841c24c2"
SRC_URI[sha256sum] = "b80596605d28714f32b5f9c68cfc6edca9f86ce6975e1b3460b867617b3d9a35"
