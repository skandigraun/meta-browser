# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc558cb61f67b597f78081ea78b25afe"
SRC_URI[sha256sum] = "1e6ab246a2c3baaf837f31050b67e61b78ab59cc3f2ebc51b290bc5586e3ffed"
