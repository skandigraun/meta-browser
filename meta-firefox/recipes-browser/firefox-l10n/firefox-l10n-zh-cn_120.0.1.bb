# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e2f4fffb16cdc35a58f5bd2d15467fa"
SRC_URI[sha256sum] = "9bcf8d502cc3e3ab9d187064a995aafc9b71e7a0fb7751d1f0c135d15bc32063"
