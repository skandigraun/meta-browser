# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78b7a336ef639c3bfd68a34d92f8b18d"
SRC_URI[sha256sum] = "5f749a4d2fdd6d45d03fc5facc25d18f08dfa2bf088dd94466094e7d44baa409"
