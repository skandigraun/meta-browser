# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9849157c6bca9acdb3632869b6478fc3"
SRC_URI[sha256sum] = "9b5bbccc2876b24b5988133c017c7cc3b3a697cc41ffddf0165c11e18f2008d5"
