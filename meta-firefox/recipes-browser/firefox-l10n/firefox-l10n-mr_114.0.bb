# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e774dc6e081d3b27d237d6a232daed7"
SRC_URI[sha256sum] = "82baa25118153388a0ab7b9c2ec4d89ad52c1acd380141e0bb301bb698371563"
