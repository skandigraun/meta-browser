# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa796d5f700f9ce6c0e725046087391f"
SRC_URI[sha256sum] = "49bf824bcc83243123717e78bbf7ca8f388d61436b29d42df94291de76287be3"
