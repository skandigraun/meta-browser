# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "569886953774017b0aba9b90e6eb6717"
SRC_URI[sha256sum] = "46e28012f594e2790dcf983a332fc938f9980928c278b08bef00b081fa8f2734"
