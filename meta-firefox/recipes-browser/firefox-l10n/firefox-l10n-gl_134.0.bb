# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d44b7b6bff03c93267c0fd07efaf944"
SRC_URI[sha256sum] = "1023583b9b97be369688bda65e5778590c8ab9a710f85e945f58a385e4a06bea"
