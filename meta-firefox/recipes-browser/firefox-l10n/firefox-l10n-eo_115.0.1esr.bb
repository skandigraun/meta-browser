# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08fe027a300da08b11e24dd3a57dd941"
SRC_URI[sha256sum] = "a6791b5d732ce6bcdf277644c802c0d1d46a0060483b649553a9f31b8e290757"
