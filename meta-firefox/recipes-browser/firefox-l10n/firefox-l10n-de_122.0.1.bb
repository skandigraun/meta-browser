# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70a8c5877b0d80aa3ff1faf497284308"
SRC_URI[sha256sum] = "178963305942518aa546358293dfc26fa515d38b1349c3d6df620cc3af904e11"
