# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6d2e0d7a310ce2af12e56df43c60ed3"
SRC_URI[sha256sum] = "c05cefac16b67f291219bdc297179f51da8efc14419fbd6dcc7f299bf32e6685"
