# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "062377f5094a5b6dce0f286fee248fae"
SRC_URI[sha256sum] = "c707ff10b65d651f448d81805eb6803fb9f25c623571c1213b8833dbaa7191d2"
