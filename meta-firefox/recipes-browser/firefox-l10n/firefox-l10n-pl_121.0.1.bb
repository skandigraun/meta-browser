# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d98d2e47fc4b3c16f401eda38f2330a"
SRC_URI[sha256sum] = "8332fbe4cbb8f266e4c65c15dc8755f379d5bfa003ccf158a5499d7a0b11bdb9"
