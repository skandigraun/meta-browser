# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "715f17c4e283e4b036023479cedbd1c1"
SRC_URI[sha256sum] = "46a6404d1e1dd2ce70fc4391665b04b8f06c521eee597a401c05e009b15a48ad"
