# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "241cfa31d65cb68a5fcc7a731563c329"
SRC_URI[sha256sum] = "2d2c11ad2c313409035684f1fae9e4f526f468a2964e1c825167320185c288ab"
