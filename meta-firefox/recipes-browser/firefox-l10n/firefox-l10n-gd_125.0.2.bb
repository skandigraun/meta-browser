# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f16bea7b216ef6171fcc2e2eaed5b8f"
SRC_URI[sha256sum] = "cc0ec80b8f81677551d3dcc00f7a8f8ef34843d1c3ec4a7041d3311e9563a810"
