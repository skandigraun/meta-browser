# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c2865f999ee95b621f3c20933f6c16c"
SRC_URI[sha256sum] = "87ea2cb91f19595c957f1047902727e7720b55cd540f697da5fa0e63f3f7a819"
