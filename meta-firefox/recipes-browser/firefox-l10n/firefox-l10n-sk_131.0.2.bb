# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "030c98948ecbd52940033466cfc5c33b"
SRC_URI[sha256sum] = "c1cb35e29f9f51fdf09f8fe2b5803e9ee2ebc8bf0ba6b54db3295ae9dfa160c9"
