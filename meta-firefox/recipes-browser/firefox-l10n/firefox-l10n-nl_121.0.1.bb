# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f0a555aef11a13066d7d79d28b2bb0e"
SRC_URI[sha256sum] = "dae4c3712fa4ed91069ccb29e1028b80aa9d73f426b7721efa7d869abef43811"
