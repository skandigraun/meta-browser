# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e7d59ab0dd2950916d615325a1ec608"
SRC_URI[sha256sum] = "8b0a53dcb556a648b7c146163acfd848b9f71f78eb98c1c9db62711c780b5208"
