# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "513968a7259d79d5a87c9feecc446ad5"
SRC_URI[sha256sum] = "ff96e801074a1343ea9a122d3078250a961eb7da29ecac542a0c84186a17f010"
