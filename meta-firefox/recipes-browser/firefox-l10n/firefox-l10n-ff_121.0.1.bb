# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3939dbd3f9aef278d6a09c10b0b9c9c2"
SRC_URI[sha256sum] = "7f047602eaae60671683f9d99bc96a2b445bb008c8fd24ff57e4d2456b0a1c43"
