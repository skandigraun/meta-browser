# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aee818419f1861432ff9237c23b1f99d"
SRC_URI[sha256sum] = "60c7e0d7bd7d674a84673c4699020f21ee97dfec41da3e2ce3ed77a283c952c7"
