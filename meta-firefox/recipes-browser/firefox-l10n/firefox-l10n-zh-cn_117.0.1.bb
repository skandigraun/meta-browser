# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4b51eda7ab34cde24d8c9f0901a694"
SRC_URI[sha256sum] = "5d425cfcb187db10b051360a0664baa8efaf5248e56a96859e54a486ed3e2576"
