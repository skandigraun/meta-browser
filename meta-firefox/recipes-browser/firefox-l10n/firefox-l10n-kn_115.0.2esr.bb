# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a81abd695448b5664a750241cd25fb75"
SRC_URI[sha256sum] = "e18072336817a5b343c2bcaa724b92c51dd335818ed063379c372f0f295b03ea"
