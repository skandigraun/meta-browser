# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eeb4b8e067e27e52b0d3b8b0f251800"
SRC_URI[sha256sum] = "21ec65ec864f5a03268cd591288bd4c3d06091c1d2b5f0063f901d1f3dce013a"
