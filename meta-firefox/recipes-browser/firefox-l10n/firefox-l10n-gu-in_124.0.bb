# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48075954c615d018d816830722a2d431"
SRC_URI[sha256sum] = "044c5055a4ef678b3479094543a3650bcd1b0eecc7527fa79c52f1a359a8dbaf"
