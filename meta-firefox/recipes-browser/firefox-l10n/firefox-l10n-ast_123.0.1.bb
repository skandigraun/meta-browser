# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0959e65966894c5394658d3d9b1b11e"
SRC_URI[sha256sum] = "68318c50aebea2725e87b83f1760d5b1acde1a158b29db4564b2f9a674259381"
