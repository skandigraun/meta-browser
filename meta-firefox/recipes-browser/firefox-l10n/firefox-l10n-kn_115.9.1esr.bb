# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "caaa166ba5e0d592135e43e04d84a9fc"
SRC_URI[sha256sum] = "7cce701bb4c6fe5fbe27ba335344bd0e22e88466a9b56fb453fab1d04cb0667e"
