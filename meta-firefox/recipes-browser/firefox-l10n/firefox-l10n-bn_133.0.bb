# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e67c0990d2d32265f3c90fd5043f4b3"
SRC_URI[sha256sum] = "a7ece365254d86687a5d6f1a4c60646ccbc2adb2b9103f59af6d3fa468ee16c7"
