# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d90910007018965efba46e0fa4d6044a"
SRC_URI[sha256sum] = "34cb8b63f719b6d9ba185d107adbde4825bb1064797aa79625e76fa0fa21df28"
