# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba135d6d3f4f3d4cea411417149794d1"
SRC_URI[sha256sum] = "cfff15af17ea48405f4eca4e1a0ecf400e8c42d9fd6cb04dfde106f2cb29f341"
