# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1fb95b049c2e281b23b029d15a5f2d3"
SRC_URI[sha256sum] = "3edcf7bc0416876cfafb94d5a344d30d5da89e17e2312e475155f016f8dfe221"
