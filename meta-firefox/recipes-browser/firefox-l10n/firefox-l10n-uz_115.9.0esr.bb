# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c06c877068587c2c6b9dc88e4b8bf7"
SRC_URI[sha256sum] = "0c9f4424c3e472573383618a6a4171fa58b6ecefbc506fde23041b8b9a12f860"
