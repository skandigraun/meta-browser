# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2882c65b4695ec66d28e115bfbd1944"
SRC_URI[sha256sum] = "352cacc618ab58c7b7e2b3073f2932f33f9b2d7165f383a4327ded42f07b561c"
