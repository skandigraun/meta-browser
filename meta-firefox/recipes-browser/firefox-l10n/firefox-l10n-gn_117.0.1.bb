# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "444b70482963333ad17d213f1bcb9901"
SRC_URI[sha256sum] = "583371c9c4c49eb0f738d875ebe2a1cf8b60e7273f56f5ec52035e75f7724461"
