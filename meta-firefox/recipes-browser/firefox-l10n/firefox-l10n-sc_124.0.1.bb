# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b626cac0c893acae79a8c9b33081c5b"
SRC_URI[sha256sum] = "c6ffb0c3afdda9e366ee478a4fe411b9290e7b4fe5995ae68fb9aa0b12081a35"
