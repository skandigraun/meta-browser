# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3951ad29fe80692bd5e0a08366ac14d"
SRC_URI[sha256sum] = "b49db14468b2ce886c609ef946f2b5de3fb97c9cd77b3a0490c3056fa9435f74"
