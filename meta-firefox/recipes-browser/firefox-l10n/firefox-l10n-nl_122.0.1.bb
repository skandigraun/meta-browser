# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c03edfc5480674296d7aa188230c295"
SRC_URI[sha256sum] = "5731f3a6bf195e772bf8338e10f1970a8dea1cf0640ef33cc3ee244ba26025fe"
