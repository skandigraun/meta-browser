# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40bf5a747199e352d0af3ad8914e7053"
SRC_URI[sha256sum] = "f894b7deb0782fcee74d70ae407679206b6ab2ddc7eb148db69de469b293e79b"
