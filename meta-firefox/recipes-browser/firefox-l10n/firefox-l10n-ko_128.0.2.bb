# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7fcd6b06affbc48a13386c5d57217e9"
SRC_URI[sha256sum] = "99d667db58c4c323386407f927f90d9bec3cf2e33a33a6c8cb8b0af1f3b85d75"
