# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7c9680a956568e7787d9b521abfc1d6"
SRC_URI[sha256sum] = "1953b0ebfa85c7b707148432ac084796e8b1a8bd7506b3542f842ae4f121f610"
