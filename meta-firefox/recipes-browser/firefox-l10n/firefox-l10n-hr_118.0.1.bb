# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cfb3873af75c67110bfabedfc91c5ef"
SRC_URI[sha256sum] = "d504994f350cdc4fc1f3ae614c0552f0915b537498687b616c6bcb25de0d1505"
