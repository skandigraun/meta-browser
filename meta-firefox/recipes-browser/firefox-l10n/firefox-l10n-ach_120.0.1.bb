# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb3d5fcb2fdbb36a1cb7ed4a9833e54b"
SRC_URI[sha256sum] = "18bea93f524d97df03342b2fbc03e99e731a995b54e27ba3db662949ff782c53"
