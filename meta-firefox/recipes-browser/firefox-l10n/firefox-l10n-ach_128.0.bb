# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3da98f010d51c61ef7f401c1c09f6228"
SRC_URI[sha256sum] = "9823d9f70f317ed4235eb0738a4cbfadc432b4725233221c61d3569930818f2a"
