# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f552060f6356c8cfea35af188ee9defc"
SRC_URI[sha256sum] = "5968e3c7557541439d5161a7cccb3f9d9929b559f4c61525a794d7a317c6111f"
