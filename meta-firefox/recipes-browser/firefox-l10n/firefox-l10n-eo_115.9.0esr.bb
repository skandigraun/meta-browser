# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "296153ba9406b212a16937af1af342c3"
SRC_URI[sha256sum] = "23e6197a0f58e53abf5a0955652d69d62e422dc244f2d7b4ca5831e8dfdc16ee"
