# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad471bbdb0e9729d6b04df59c862273d"
SRC_URI[sha256sum] = "5736bedaf239eeffcde36c49efac632f7447239ed2f911c30b43df54d0c10c8e"
