# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d2fb0ef1b6ec4a33b92e47976e81eb3"
SRC_URI[sha256sum] = "bc993823ef2bd0cac22241e74b4f95e29d8bc8131dcd8a987f67a80acf1daef7"
