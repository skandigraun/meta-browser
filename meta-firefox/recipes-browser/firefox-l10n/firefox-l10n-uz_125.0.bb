# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "916327c5222befcc80cd494ad374222d"
SRC_URI[sha256sum] = "ba34076740498a0f50b93d4c61ddcf0dfd0cea34be8baac357f672eff5b40476"
