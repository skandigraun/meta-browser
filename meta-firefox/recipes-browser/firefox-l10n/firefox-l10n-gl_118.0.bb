# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f1ff5b8fe856cc8610deadaf2b88c66"
SRC_URI[sha256sum] = "16c39b189ff201b078e4a4a3e7c043acacc0acdfdc29af8c2574e1dac5f5457c"
