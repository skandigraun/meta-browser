# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dafdecdca2d79ecbe5c1ecb1f0d6b473"
SRC_URI[sha256sum] = "bea4b6a97f5f82e8dc1e82d9396af9fd47c5f9dc3d9c0509e021b54f9652dea1"
