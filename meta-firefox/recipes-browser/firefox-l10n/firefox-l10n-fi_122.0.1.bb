# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b82a8f5ad959450ea89a749b991d5954"
SRC_URI[sha256sum] = "269b694c22fff6d5d4401a64505dabc3ff05efb64ee74375a87cad73114799e4"
