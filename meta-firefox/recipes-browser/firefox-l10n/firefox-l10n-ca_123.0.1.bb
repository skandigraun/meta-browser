# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46f6f236ab59e9d42de598add7fc5089"
SRC_URI[sha256sum] = "2c91383c01e2974ac7e605bcdc5cf5519575143fb43c0966ea9d6b327ff104f2"
