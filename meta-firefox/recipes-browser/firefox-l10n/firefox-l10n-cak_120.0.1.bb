# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72a5c9aa8ca59bd4f834f687de70d855"
SRC_URI[sha256sum] = "1df02bdd8b09742018e7e1aba182f211a3f41bb5bec910867015993c96a04adf"
