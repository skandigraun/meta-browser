# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c843a62764cece7de3c24a6060bad918"
SRC_URI[sha256sum] = "8a5e6323b883626000ea6b08ce68f83f06885918a4fe01b48bd36b7509c71ec4"
