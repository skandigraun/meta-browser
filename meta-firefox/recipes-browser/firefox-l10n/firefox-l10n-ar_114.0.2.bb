# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "018a876416901fdf21c3443603ccf3ac"
SRC_URI[sha256sum] = "cb72b8231d327805953afd5cc1c83ffebc3835c8cb7880027373909f861a4d0c"
