# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f114f6d510a4b98a2af90722d8edc4c"
SRC_URI[sha256sum] = "f023235e75832f6ebef4724fbc58339ec6d8d8dc1e363d0a7d9a5c86727e407a"
