# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7261f14ebd94e420d83d4c24644fdcdc"
SRC_URI[sha256sum] = "1d9599fea834f47e041d4da319b14f37c34566ea42885e33a377c11dc1d370d2"
