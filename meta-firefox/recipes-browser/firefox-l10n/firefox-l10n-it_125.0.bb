# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2d24dafc89bb2e7a093b0011a449afb"
SRC_URI[sha256sum] = "d8db3673b7555a5b60e0de228e9ebe312319f9d67d3abe1200998de723539fac"
