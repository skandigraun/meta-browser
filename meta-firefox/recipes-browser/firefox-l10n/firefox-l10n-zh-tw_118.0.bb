# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8412a902d5cb66f19a12616509ccf336"
SRC_URI[sha256sum] = "b19690ffce85a71dedd33a541046f41d53c45e7a321363a30ec96fd12f8249e4"
