# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf462293f37e5e1638b8908b77026be1"
SRC_URI[sha256sum] = "ff341d26e29cd4468c21dc96a7ad457d0238c2de85aef07c66e881135e727be3"
