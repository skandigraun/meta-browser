# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9611d8e9b573b08c925b35c093c782e"
SRC_URI[sha256sum] = "f9dacfe779a96b35b956e065bf1cbf5b74fb76ed61fd1b960332158690bc6a08"
