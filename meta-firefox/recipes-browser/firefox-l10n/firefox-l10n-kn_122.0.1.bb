# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320767395eec7a5369a192c448c7054e"
SRC_URI[sha256sum] = "57a5c963134c39e7fe0e7129548f8edb7e8e267bfa8ec9362870359679d51e21"
