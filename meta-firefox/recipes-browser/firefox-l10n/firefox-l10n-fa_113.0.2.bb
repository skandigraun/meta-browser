# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "359d82104d7e82bb2fec326e6235ad2d"
SRC_URI[sha256sum] = "7566cbc5e09e9ba67df9de5b5d6772ca25068160d67ba8617e8425efc22b60f8"
