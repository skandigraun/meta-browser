# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54e56176e519b585698d6e66c300798f"
SRC_URI[sha256sum] = "0fce0c01a846c028ac780bc24b2e9ad276ff21f7874dbe4810013b8fe026cac4"
