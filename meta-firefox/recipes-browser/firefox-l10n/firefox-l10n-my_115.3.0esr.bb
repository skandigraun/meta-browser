# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c67325c7e52ecd21b6d56752df64921"
SRC_URI[sha256sum] = "a025afd96a318ca3c45285f28b126c451602a9021ebf8e803f65f58acdf4fcf7"
