# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4a30c9c595b2ae94282ee38b24a93b"
SRC_URI[sha256sum] = "a25037275783fa8b1857900fd0ae46b565b14da28bd7db8a97278340fc4e5ad1"
