# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39b11ee702c1f3d9a01f0f71892eb7d3"
SRC_URI[sha256sum] = "a8c0eb94119bfe7dfb1d0fd26744731d6eb85d55c9cf4cd9e4a6d662a975e17d"
