# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "066131f0438a86fdf3683ab54b4119e4"
SRC_URI[sha256sum] = "0db3c23472f6b45d158b9de5220040821e89be207767910121040e9cba949f92"
