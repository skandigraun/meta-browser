# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5f054b79f781b7b55fb46a8c5f405a0"
SRC_URI[sha256sum] = "4bcdf7c84a8141e4af4276b01ea03d23ac817cfc441cf37487d71960d8f1eb00"
