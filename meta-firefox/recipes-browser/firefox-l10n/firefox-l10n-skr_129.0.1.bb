# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb61c9ee4fd8dfdcca073b6b73eab9cd"
SRC_URI[sha256sum] = "e2c892c1d1afe7cc875362ef6bee9e8feb98e991e8a059667ef858da84394bfe"
