# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03fda76ae19924a34f7fe72ec9b18bfa"
SRC_URI[sha256sum] = "ef85898fac2510f451539596bb23c9daaff7ac197cd533dd582616091df05957"
