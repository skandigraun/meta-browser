# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ee287e23df21765a17e5b3c42ec20fc"
SRC_URI[sha256sum] = "edd949e63adc2867d75efd912c67d239f76967717f0b78edda240b85f2f45b98"
