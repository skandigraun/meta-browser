# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d88f29c8551ba9674cfa6ffda935d2"
SRC_URI[sha256sum] = "f221e78a0267feb9278589c817c753fce82e92ef37bd53ec22f88a08e86e5c2c"
