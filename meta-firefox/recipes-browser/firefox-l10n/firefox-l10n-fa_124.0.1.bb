# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fda40fd88f86a520ee3d7d019c5d526a"
SRC_URI[sha256sum] = "4c625935ce4b6e355ca213bc18348b5fbf3aff72f3b7fcae26f6733d9d7986d8"
