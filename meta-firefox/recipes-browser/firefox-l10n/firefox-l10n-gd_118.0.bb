# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4a3015a97591baed3f61d6bf1620cfe"
SRC_URI[sha256sum] = "3b1d24564151090f1d666f84ea657970456e17ba9647710cde44dc3b5833d7de"
