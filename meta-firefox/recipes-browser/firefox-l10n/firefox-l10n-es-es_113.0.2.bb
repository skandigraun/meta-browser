# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5af833b011d466bdb75f2610711e7b72"
SRC_URI[sha256sum] = "7e4caf89b791c3d3c14d6fd8a86a64e62dc64cbe69eac6e4f0c50d459eee093d"
