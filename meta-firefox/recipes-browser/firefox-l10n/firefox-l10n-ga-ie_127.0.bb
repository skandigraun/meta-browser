# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cb54897ccb9999c931ce965ada5acc5"
SRC_URI[sha256sum] = "f65133d993244bf3203081ae65f5e1e196647c73bdf0cb9e634b5a81a1df9ec7"
