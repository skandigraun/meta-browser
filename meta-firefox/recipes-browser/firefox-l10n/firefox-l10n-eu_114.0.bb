# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00a94353bf0acc511b97585c666d5dc8"
SRC_URI[sha256sum] = "0f607d174af36790046d1ce2219dd341e557af524f22d8afa504538e047d9081"
