# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3158cbdaabd76362abbf94e551e29e2f"
SRC_URI[sha256sum] = "62d1fa257fabadecca33e9caf9ea49558aedb9c3b8989fa5558da6a046d02e09"
