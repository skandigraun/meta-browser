# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "086a380e86222c570963de6a51fb3317"
SRC_URI[sha256sum] = "904ab94abcf1602c73b09f40bcde724de1187f7259fc53b8b10657dbbfda1560"
