# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4597b09eda44411c6f64f2f47111b058"
SRC_URI[sha256sum] = "9dab61f8122f375490a5ce882d11f9edc79a249ae4bede14935f684a722e6ca0"
