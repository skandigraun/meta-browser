# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba250820477515be257e88e6244b907f"
SRC_URI[sha256sum] = "c6b2fd79e1f5fc4102cc28bcbd7772dbdeb25aa56f5c26e037e068cddd69e43c"
