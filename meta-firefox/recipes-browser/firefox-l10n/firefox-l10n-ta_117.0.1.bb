# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c541d3e4314023a783905d8661547978"
SRC_URI[sha256sum] = "d9ac7db9603d68b44840adceed00c38dac72f8290709e10294236027c69790be"
