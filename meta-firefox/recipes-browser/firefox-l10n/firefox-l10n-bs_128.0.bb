# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15c71211d9d80dbe87974de3d77020ac"
SRC_URI[sha256sum] = "94006aeeace1770df222807cfa3df190c90fa323c8fd136b9cb8983eab8bb7f5"
