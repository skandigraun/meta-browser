# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de5212b400991b24f630573ee407151d"
SRC_URI[sha256sum] = "ef433045f3b31d9af2f222e3060443187d20c221f37d113606143254e17221dd"
