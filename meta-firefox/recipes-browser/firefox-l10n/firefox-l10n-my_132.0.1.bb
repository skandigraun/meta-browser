# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "188a1d8c8310d5a9227121ee1098609c"
SRC_URI[sha256sum] = "b9a2bb2ea20c859ab6d98417099cb9497f92ff07e035452e85c055eba5dd2869"
