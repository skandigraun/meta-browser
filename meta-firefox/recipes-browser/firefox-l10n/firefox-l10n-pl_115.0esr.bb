# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77038cbe9f25d141c7e7438b2cfe169c"
SRC_URI[sha256sum] = "57357d152d16071a598f3a2a09c54b56081d7a013a317ea5001ee0aba4eabeac"
