# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc9460fe837b5add1a35fe8368959250"
SRC_URI[sha256sum] = "e195087aadb2f1c9bdf5ca0c4800953c6e56342fb9bf8e11f041870da326708b"
