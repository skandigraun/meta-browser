# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a185f205c401ff12b08b48f9cfbcea66"
SRC_URI[sha256sum] = "418c0ac88a4681cd00c2e0c016e993d5b1a5e2545115f13c43aab32061984d1d"
