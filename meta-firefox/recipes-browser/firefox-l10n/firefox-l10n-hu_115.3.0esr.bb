# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "822deecec0182c700265ebf79e83f4e7"
SRC_URI[sha256sum] = "8ea755eecccb73735c72b3957398765385056141618616f4b0729f441cf9b610"
