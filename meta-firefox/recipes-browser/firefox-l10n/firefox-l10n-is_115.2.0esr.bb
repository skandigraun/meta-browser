# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a99f13e47e2e31736a9c4729a019fc3"
SRC_URI[sha256sum] = "5c02561335b2d8e3b64995894fb9228cdc3e122b50d750e1648944e4263e6684"
