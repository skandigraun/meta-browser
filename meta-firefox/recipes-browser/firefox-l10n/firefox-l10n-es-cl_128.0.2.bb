# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "defe013591c0cc292d69fb6eb0a69eab"
SRC_URI[sha256sum] = "d86f245ec39af1f76be1200741ef415907763115d4ac468e2c2b5eaf35159f22"
