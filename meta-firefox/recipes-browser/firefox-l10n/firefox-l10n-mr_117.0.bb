# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84ee4aacd7141be02cf704401253590f"
SRC_URI[sha256sum] = "81c37b63e5d3935977f90ab5beb49d9c010b7187b9eeef2b3335de265eb57b10"
