# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e5b93cd248f44b3c3c373d0967b831f"
SRC_URI[sha256sum] = "c432c8bca53c7d2f8272435a7251e95958bd77c18c7d66fe06dbd230f3f0b8a8"
