# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c131d57fda541aed4e64273d787881b8"
SRC_URI[sha256sum] = "effb7720ba1deea94eb2f2f291e6ebb690a5c68ed1614f20ad6d6a1eef366bf9"
