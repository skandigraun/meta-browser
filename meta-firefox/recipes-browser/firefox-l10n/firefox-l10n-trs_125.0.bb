# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb5041afe16155a6b41777cd9067ab01"
SRC_URI[sha256sum] = "1191d65b200d2aa046384a79b76d7a7d80c9c3528cd2f7b55fb3a29f9cf60fb7"
