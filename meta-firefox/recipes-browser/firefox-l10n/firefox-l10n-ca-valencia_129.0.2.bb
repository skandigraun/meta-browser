# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08d45841daa7bad2b33b41111d645c66"
SRC_URI[sha256sum] = "0bf102d51e7115b8e360d07bfcbc890ecf6b7b2ae53d20cc5eea2cf2249a5ae1"
