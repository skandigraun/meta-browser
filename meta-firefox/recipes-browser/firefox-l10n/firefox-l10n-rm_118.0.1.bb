# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea8aa15174696719b6515fb4cf180a68"
SRC_URI[sha256sum] = "6c1568e0a0642c3d5d790367d0fac393ec092eb2898e6b7b2b102dc0de524576"
