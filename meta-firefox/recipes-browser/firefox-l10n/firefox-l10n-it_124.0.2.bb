# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a241996a8643b8527cf415c873146690"
SRC_URI[sha256sum] = "9d857789fcd007355d469120542e0e459d0db9ea977d0c2408c19c5277562b17"
