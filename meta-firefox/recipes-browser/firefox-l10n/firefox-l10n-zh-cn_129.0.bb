# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34081a942db63694544e8669dbc8ff93"
SRC_URI[sha256sum] = "5a161c9a2b2af257fab7622269f833f1c2d96f45eb7b8ec07b4ccf2cce86c296"
