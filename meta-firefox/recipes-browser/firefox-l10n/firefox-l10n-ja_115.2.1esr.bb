# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a07ebc1a6c800fd0e7968c37fb3ac06"
SRC_URI[sha256sum] = "7759880ae748a22120c2e2fb973c918abb4a57a953ee7088e3340095322fdc1b"
