# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0144174f65f25a647993d00914ff3bd"
SRC_URI[sha256sum] = "78dff8339ef667a85dbce3801653e26ccd148983e07d639a545be7886fb528f9"
