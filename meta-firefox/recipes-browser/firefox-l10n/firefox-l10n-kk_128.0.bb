# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce7b592ec5cc63103484f47f1b0119a"
SRC_URI[sha256sum] = "696a725280ca0596c25225f219025f529fced1783e1224bf964e83bbc1806eb2"
