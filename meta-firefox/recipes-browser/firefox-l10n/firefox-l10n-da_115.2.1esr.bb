# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "960ce54fc635ad8e45f199f96c0ad8e5"
SRC_URI[sha256sum] = "583b44c9c108040e9d39d23fc4a33c2b6e6c8bdb3b3d4df063ce810a8c4cc414"
