# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db37853a2358dde519c24ab630243c06"
SRC_URI[sha256sum] = "a7d0807b0543ede17beca15b787edf4e383747d515768e02fe4bac38770ddefa"
