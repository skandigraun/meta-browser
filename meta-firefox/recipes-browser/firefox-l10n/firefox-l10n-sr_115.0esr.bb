# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac4bba2c690e2c3a084e08e781e8f449"
SRC_URI[sha256sum] = "85c174ef50b9d8208b875b0baaab789a63af62902d054031af5a8c286637eec7"
