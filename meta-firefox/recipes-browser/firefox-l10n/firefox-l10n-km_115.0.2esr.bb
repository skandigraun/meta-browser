# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a3025dee762badf26b33d8ac07d311f"
SRC_URI[sha256sum] = "ae3c5e59f982047506ba9d0e3e2646508afd30eb8ca892aa96240e6a090cfdfd"
