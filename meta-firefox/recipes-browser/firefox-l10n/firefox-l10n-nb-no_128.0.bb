# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4cf85f55e2f7a0373c06296e252c504"
SRC_URI[sha256sum] = "34af56c10b44f06156c564833cee69beec437b3ad4d5be8048fad99b82b2ac35"
