# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ba023ded66b17b97eb9d3b8cb06acb5"
SRC_URI[sha256sum] = "2bcc82d3a4f8390759fa22f4d836183b05b53f2b36d6eb36ca7044f3db08fe64"
