# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6e4742c925d120e7f6afbeda94a0b45"
SRC_URI[sha256sum] = "cf3ac6a3a3a58d3b9d5365e3903691aded99b5e5833fb64232832d184ce26467"
