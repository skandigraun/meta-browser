# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7c46cbf082df1fee3abe00ddaee644a"
SRC_URI[sha256sum] = "f37719e42034574d92888d5fa8ab38668de886b763efffe23ddd33d9f0288f8e"
