# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfec904cc8581595c17494de1afa9e85"
SRC_URI[sha256sum] = "65d42b7bc8fe18133311d88f02e5684016b2be999837dfdafb0d4f4220698b4a"
