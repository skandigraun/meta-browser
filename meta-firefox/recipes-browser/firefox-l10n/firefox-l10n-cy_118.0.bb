# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c529fe98eb3521b4b4339fb61eb4e12f"
SRC_URI[sha256sum] = "a60a08d6807600d584b6b75eaa25ea18b28f3ac52c2f527f4be97fe68bd9f9e5"
