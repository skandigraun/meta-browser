# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1154389513aa30a79d1ba921b103f4f2"
SRC_URI[sha256sum] = "9d93fcb97468226c897260c41507d2310bac62bce56a11d489cbc1c5c8f5fce3"
