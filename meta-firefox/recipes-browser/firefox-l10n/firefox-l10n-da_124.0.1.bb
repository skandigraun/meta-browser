# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7b280021538b800dd8a659557b8b217"
SRC_URI[sha256sum] = "67829d67317ebbcfe70c8c560d1af5837d570519ffeba6b0dba8e2c4606fd593"
