# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8d6e7fdd414b48a3569c694677612b6"
SRC_URI[sha256sum] = "61356d776b6341a0802ad6974bfd133db0b93b5430eb55d21167049a8626b603"
