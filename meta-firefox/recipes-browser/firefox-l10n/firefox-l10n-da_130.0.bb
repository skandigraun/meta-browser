# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "546978e9db0d680b8f930b265b271e7f"
SRC_URI[sha256sum] = "3381879cfb1a2f4664d21165f0e90f9268fa831c7013510587312306c7b6b53e"
