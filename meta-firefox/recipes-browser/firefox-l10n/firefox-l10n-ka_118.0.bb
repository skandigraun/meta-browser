# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6de5e1ca268b51cb74cd1103cc868e9d"
SRC_URI[sha256sum] = "90633b09282353a24c11e2571b5c8fb3e0cdd5d644c449b190addf4058042a08"
