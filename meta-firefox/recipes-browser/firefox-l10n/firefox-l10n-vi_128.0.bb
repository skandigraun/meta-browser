# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "695a479688e4d239e59a995b109c62c3"
SRC_URI[sha256sum] = "ada37adf9d317952e459034435d2c121a2ae8c63eaff7667a56d4bd434aac1c7"
