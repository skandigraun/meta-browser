# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b449bf9ffe9924ca1a281efcab42095"
SRC_URI[sha256sum] = "13cb6dbaf43b4523c7fefdeaa1dce4ef641d8edd324c9ecd0961f19b774f77df"
