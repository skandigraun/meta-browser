# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "caa8f51102cedfdd927ad9cc527d316c"
SRC_URI[sha256sum] = "1f0b00afbaa8e8bc8bf43fc9940f7289236fa6ad7b4c9596a9c434dab8bac1d2"
