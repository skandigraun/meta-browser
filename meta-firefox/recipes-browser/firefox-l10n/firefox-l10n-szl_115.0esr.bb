# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cda0f1d36f8406ae096a16d078eef75"
SRC_URI[sha256sum] = "142e9442da7eb8e968fba2bc924087d0bec790145f475ffec42f7023a1f5057d"
