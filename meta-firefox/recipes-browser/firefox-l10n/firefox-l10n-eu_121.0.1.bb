# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d0cf5d6460c7773b0b84c2c2b408a13"
SRC_URI[sha256sum] = "2979f5729bd916ce7a6795f3fa26c51650db6d589ffcfb1b9615dce1673c38b1"
