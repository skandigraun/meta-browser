# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef32784ade74c826631260e4ef07d9d3"
SRC_URI[sha256sum] = "cd9a138a9adf4b321f7da916c08381227ba3ab69158ba6762c1d40463151e1a8"
