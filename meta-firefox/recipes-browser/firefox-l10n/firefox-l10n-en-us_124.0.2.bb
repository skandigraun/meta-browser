# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a42a4650f7f5e02ae8b7cfb212038b9"
SRC_URI[sha256sum] = "3ae6d0f78e10c02bebe65a8669152355e89742fa958d8e03b81bc1d0938a1cd3"
