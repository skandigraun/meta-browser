# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7e485600f0691bb781ae8b17e459490"
SRC_URI[sha256sum] = "1853e2199c7ab0497ca197ad9c632c89c4bc063f62feb7028ccfd931921821f7"
