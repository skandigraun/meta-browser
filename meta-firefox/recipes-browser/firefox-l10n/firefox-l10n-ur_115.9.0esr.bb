# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26f36b54f9c3c73492b2f7076879663e"
SRC_URI[sha256sum] = "fc5f2cf86fa707066ed4493f4d5c696850ceceba5f918a0c1530168f75923e3a"
