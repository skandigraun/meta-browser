# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d40f4b8cafe5030b578d60a4baa1803"
SRC_URI[sha256sum] = "9bf2dc661ae487808c4b467d5b0743a8e18c4f9b03945c8e166abb1a4f0fc520"
