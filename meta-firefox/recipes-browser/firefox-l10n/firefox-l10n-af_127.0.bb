# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6371523f2cafd2afd69a75b949a97a3"
SRC_URI[sha256sum] = "9f00bcb35cfc1b6a3c4d704750594a56aa4eafb2fb7f2549201f4d2e4e860301"
