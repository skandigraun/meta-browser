# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1036ec85b8e2cf3dd2a8e6c0f711471"
SRC_URI[sha256sum] = "982529997cf996e039ceab448a7319a7011a93ab567d61cf14cc36d7f858fca9"
