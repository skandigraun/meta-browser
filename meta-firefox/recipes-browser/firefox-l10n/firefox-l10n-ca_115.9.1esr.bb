# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b62f9828e1f031997db3c59a70f49aa6"
SRC_URI[sha256sum] = "97b5cee5109c248b0969d0f7ef2d56983261a808baeea2a033703834b4a5a50b"
