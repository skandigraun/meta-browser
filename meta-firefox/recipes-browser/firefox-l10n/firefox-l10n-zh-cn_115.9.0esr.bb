# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61ef8c0529d86390bbd4e0fd58f00966"
SRC_URI[sha256sum] = "8d641d74ade09218128064c2f58b075248dc596d04916d46f50a06a201f31b5d"
