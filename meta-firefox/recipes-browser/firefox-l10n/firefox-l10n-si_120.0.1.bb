# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "793f8ea5198389575ac43096a7c4f1cc"
SRC_URI[sha256sum] = "ec73ad1eccf4b9d555e7c830da655ef58d33609ba1f0cf0e6a6688a48b722074"
