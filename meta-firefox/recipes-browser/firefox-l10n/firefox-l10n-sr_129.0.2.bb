# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6cb73221001f4b46f04eb932c709abe"
SRC_URI[sha256sum] = "3468953b586bea39e79c9a2e25133dd1829078eed3a3b31a026a29428d44c376"
