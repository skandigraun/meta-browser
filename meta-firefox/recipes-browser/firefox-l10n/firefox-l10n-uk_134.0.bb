# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab3f1258ba540b02c7b47179422c7726"
SRC_URI[sha256sum] = "88dc5c26ec7a96a5afb798b6e3ac27185eb7ae0fc894343f7f022306e07ad44b"
