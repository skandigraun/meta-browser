# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffd3f8d0dbf05df76af55e44ebec9049"
SRC_URI[sha256sum] = "4d6bd72467436cfdb3fa8570bc053a0e37e8bbd28f1b8636ee6958f22460103d"
