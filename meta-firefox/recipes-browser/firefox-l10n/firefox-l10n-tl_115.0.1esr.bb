# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2540b219082b43f39d44b0ef7da58b0"
SRC_URI[sha256sum] = "d8e02080589c9a28b2b8c3318cbb58dd8c0401c2d5d06899f34aaadd1022168a"
