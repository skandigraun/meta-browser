# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16f0f0e95834d8d5eed2bfe7beca43a6"
SRC_URI[sha256sum] = "b8e43111482bd0f5355bfcf44c1401daf8b8be6271173057fc58606326790e1f"
