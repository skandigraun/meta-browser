# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d380d62a822860702dde26b3c9cd3ca"
SRC_URI[sha256sum] = "4064d191293b09c519d421137b24588f08039ca0991ac818b52f075cfac4cf0f"
