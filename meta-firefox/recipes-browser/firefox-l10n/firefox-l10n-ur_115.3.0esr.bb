# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d290fd5520e2e0fa52b3a69863246bbc"
SRC_URI[sha256sum] = "c7e6f2ff8b2a0aab1a20671811a6860792866a909681bdc1eaca422904a28984"
