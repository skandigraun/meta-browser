# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00543f222e5129d08f3db1b1cd300ddd"
SRC_URI[sha256sum] = "aab7993429e311afb878b4570ba37f22536383c7eaf0f3725c656e43c36a8ca3"
