# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42f2812ad255ff8cbad44f776ddb30f"
SRC_URI[sha256sum] = "e20881067330c3f0ad58cc58958380e30d5f7c2ea85bf6f3e0085a88b557b536"
