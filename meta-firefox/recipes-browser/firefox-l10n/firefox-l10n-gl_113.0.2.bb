# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2880fb2f83c41254981b6bbf110901c7"
SRC_URI[sha256sum] = "1febabfa653eb463d35bce7d870a611040669ada333102f4acab9330d35d558b"
