# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2346fcf2c0df6e90605f6021267ef36"
SRC_URI[sha256sum] = "441c29da5c76372bd33fe701786dd8cab30b1932a0574f7ddedfdd6f913770e3"
