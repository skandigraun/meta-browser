# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "086f3c036c9a9d9c48da3c6a8f32a035"
SRC_URI[sha256sum] = "4aaf20be5af1dc1eb28c29c552089be02f477a066248e2791576c5a231c4075c"
