# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a89dffd64f8b8e676420fec138ea877"
SRC_URI[sha256sum] = "434d79688e0d2c4c240eba79e7c8bd7213f98dac8cd7e78a02fb9bd390f1731a"
