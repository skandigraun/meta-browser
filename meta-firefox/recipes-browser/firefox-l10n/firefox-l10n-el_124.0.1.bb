# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbddcc3c246ec0feffbef521dca2c73f"
SRC_URI[sha256sum] = "bbd22884167920a2b510a2dc515e8f40f6d8c781465acbcab7f6669a17073243"
