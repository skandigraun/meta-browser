# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f94e346268c4df4583d08ec704dbea8"
SRC_URI[sha256sum] = "ffb238c2b7d89c3d96c4487f12fa9070d47ea87a9d08394c01f3625e275f1614"
