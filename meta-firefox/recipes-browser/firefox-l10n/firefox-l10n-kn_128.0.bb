# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3febd5642f3621e62983da1a8c719d5c"
SRC_URI[sha256sum] = "8714593ff1808855e6bcb2b1a3fce83bb3550d0772932335e0344dc515eb37f8"
