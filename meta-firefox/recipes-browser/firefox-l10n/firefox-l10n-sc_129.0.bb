# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6a622d5f51e356d887992e6fdba7c10"
SRC_URI[sha256sum] = "41c42f04bd8a1b8b9c57c3204e4e1f518ff5db6db334536ec017afd0b001eaa4"
