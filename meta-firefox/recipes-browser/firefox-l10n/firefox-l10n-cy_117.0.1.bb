# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "784265a836f907e3f8d77607d2ab05d3"
SRC_URI[sha256sum] = "ca31c209a74ebc29e74c03154a4d76683d9688bc9d1a908f04d26b833d6ca374"
