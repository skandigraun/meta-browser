# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "717e78382863785e9ce9359173548fa6"
SRC_URI[sha256sum] = "db8d7c449a85952fc58c496c7759da3ca0cdb18ba4b6000b3bf1c5be61f4f2eb"
