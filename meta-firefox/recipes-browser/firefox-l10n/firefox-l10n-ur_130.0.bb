# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b17a9819c22408a4b0be3867ece3789e"
SRC_URI[sha256sum] = "50edbbf915e4d3360f0b6ee9220f93d02ef5f9e6bb5625113709531b01bd0a64"
