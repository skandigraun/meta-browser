# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc2f703d6e1de4cd93b29380c07950c"
SRC_URI[sha256sum] = "48d8e4a4cbece9b61667148a934e93f6f74de7e17850370c0aba69eb6a4dcef6"
