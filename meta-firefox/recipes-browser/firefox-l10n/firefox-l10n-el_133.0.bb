# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86ec0a874d7ea0dfc294a4b3a8584af5"
SRC_URI[sha256sum] = "aad50406ccf95e4d40b91099e98c835118c99aaae1689f4029c582a6d1fa8451"
