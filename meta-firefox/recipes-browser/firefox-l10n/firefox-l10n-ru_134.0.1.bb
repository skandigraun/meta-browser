# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "670c30d056f9f38af8da35b0ee295e88"
SRC_URI[sha256sum] = "8376e97cef7481ffba6e00741503ab2c9064bfeb8556c166698afdc0b45d8242"
