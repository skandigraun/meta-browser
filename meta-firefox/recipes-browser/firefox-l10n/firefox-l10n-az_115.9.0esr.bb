# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f24167835b9fbf0a27fd441616cdb313"
SRC_URI[sha256sum] = "9dbf69fdebe0b02c78e2e0983442fa5d67be3ffe1804cea6cf964718bdf3f959"
