# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d96d9d3f95253264bc79361a427bf62"
SRC_URI[sha256sum] = "d3bb65aa80e1bf2c329fc56e7450569d0f669952e0691c2900c12df19f2b7a0b"
