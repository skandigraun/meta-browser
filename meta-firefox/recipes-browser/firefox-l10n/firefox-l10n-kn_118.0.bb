# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e361d2d976a61ec67ccbe5e22744d17"
SRC_URI[sha256sum] = "371a2fd1898df1b93da89a3f307142ffda2b373d375ccd21f1e9669519a399e7"
