# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "100d3e325b4e0ea4b8d3cca66b67f5a1"
SRC_URI[sha256sum] = "87674c4ee82b49f0baf97685307bb8f4b9cd520581987e1d7faf8e7dbfb83b6e"
