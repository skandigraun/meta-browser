# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e668e7c0deb9074c7ac9226647cde9cd"
SRC_URI[sha256sum] = "b681b27dca0384ed937a2d68af99a2fb56ac7e5b330b9f1ce0338a51d7d8c3bd"
