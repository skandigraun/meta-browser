# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3beb4720a4f3e9634eb3d6e1e2676772"
SRC_URI[sha256sum] = "d7917e96cd197477fd3e7dfad6177da0e55aa262e541c431a52c47091e21bff1"
