# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1c2be7a3bebe2737e2d2ad1784b1a84"
SRC_URI[sha256sum] = "089c788adb0730f5d7a78ba2a5ed8dbe079b1cc360d6d107df519f8a1623b084"
