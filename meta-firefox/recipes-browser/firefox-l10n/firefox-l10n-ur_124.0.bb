# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63d7be17e8c0cd8aaa3eb9b84de4cdda"
SRC_URI[sha256sum] = "aab407af4b040f6f1a17e54b6609854998bc7f109a0ce33f729e73021889f638"
