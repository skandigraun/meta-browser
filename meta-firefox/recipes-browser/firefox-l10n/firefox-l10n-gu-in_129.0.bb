# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e919ae0976916d225ccc44bda769669b"
SRC_URI[sha256sum] = "16e9c85581a958bb3b5d2ea4347db145d09bf2bc9992ddbb78662a9d0bcf4de4"
