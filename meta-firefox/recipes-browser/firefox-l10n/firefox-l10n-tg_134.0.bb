# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e317ce722f81bd32f0832859b56c9df"
SRC_URI[sha256sum] = "555cb2c5c361c0bdfca3a2816e8f778cb5a1acfe574f3b6dc93293ece01c606e"
