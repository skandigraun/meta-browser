# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d2c1c174a396a6a41b5e055d702bb9a"
SRC_URI[sha256sum] = "63195757498c69735cff94e88b6a5bcf2495b32e75bdca33fbb40218888c165b"
