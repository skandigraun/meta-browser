# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73e3aa64a5bce813bde3ddbb1169624c"
SRC_URI[sha256sum] = "71e09f33207494f6fa4a6dcd3601eafa543c43342ccc5577c93ad20242050eb0"
