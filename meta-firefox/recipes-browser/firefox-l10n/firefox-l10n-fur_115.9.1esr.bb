# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d51562e02f3baf1cc37ded4c56331ecd"
SRC_URI[sha256sum] = "a75cbbfa360cf2ab5a7376827b4fc6eae786c7feb29337729ccaada586be0c94"
