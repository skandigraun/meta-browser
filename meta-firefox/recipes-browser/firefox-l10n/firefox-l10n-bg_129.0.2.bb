# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69d66db401b4578d7166d6e1ef631851"
SRC_URI[sha256sum] = "8d3fad757e2bff63826dd5cbe75cea37a5e156d405c7747d9126a3ddaf7d9e1e"
