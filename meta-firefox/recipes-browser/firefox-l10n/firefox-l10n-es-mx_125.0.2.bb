# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ecbaaf4760074c7a66b069c45225f3b"
SRC_URI[sha256sum] = "768cb330f95c9b5d9b11493fbe3230ee8b1ade7d56a7760ec5297408ebeb3071"
