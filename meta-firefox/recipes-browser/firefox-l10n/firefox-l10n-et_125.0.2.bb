# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9965c9411fb7913cee089db600a07758"
SRC_URI[sha256sum] = "90e81f15a42911b6dedc2e3caade546eae29e4ae04c8c84976a9f32f0215ca10"
