# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de68cb6acb94ff047562bea18e67e17b"
SRC_URI[sha256sum] = "8aa3c2db2a22f5b079cbee5df6e22d32250cfcb79d002230730aaadbd8e9ec19"
