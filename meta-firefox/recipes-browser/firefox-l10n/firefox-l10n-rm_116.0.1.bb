# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef823225260951c37e9d346b2cea8843"
SRC_URI[sha256sum] = "7d6f1d8c26531aa7f3a123ae50818347001a3210a998d87959e954158ce8d242"
