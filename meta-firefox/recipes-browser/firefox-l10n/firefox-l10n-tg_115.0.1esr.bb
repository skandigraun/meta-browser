# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "333f1a316faa74a7056b42fd3e6367b2"
SRC_URI[sha256sum] = "6785b02d389e1af47cd92c178b2c2bf746ecd48ccd308f6ef2a81684a74d8fe1"
