# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73cfde1ffab99c19d81ce4509b1dc1f6"
SRC_URI[sha256sum] = "c89b9db6d7a85860460b77b66ed5edb53f4da873c0569c6cc0f8cbf1bf5d703f"
