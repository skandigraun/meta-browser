# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7baa1416350b996c77f3cd5f83345dc"
SRC_URI[sha256sum] = "7e8efa5a14d7dc968864be7fde8a75c5fb5472e88767db8f2607e4a1d390ec6e"
