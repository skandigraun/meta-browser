# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f0841db5e80f1d5edb01efa36aeecd7"
SRC_URI[sha256sum] = "4a9fd074caa421494a4692e848f76bc99e7f000e4b151159859ae26c10930661"
