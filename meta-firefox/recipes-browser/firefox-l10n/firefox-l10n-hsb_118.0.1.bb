# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb582861055a778b3e65f82dd8165656"
SRC_URI[sha256sum] = "c40e59f5084dd440a9ef73ec726d108ab3d74dafbb61a2c246f88ebd4e405b16"
