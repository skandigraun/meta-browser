# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc391647d5750b98d8e7b5571f12a9b4"
SRC_URI[sha256sum] = "6cf6a18c029884bfc9d1fa668cf01dfd9bb3dd2c38001ea323c174f8f41a7ec6"
