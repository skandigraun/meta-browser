# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "babf0d8167eb3ca194cf433c9c1d99d3"
SRC_URI[sha256sum] = "b585d503c68e317a414c57dab4c5df8c1b8a061d910c2b5faeba5bb842faae9c"
