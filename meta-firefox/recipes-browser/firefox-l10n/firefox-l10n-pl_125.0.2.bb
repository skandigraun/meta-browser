# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47dbb3dd6b2db33670eef5385925ebd9"
SRC_URI[sha256sum] = "41118f847e9f98acf88c329118daeaf7e843ac357d0d6d9a5c6ff74f8d3e3cee"
