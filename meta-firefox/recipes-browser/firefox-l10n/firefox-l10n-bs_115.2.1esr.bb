# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5921cf4bc6a2610dc3986614bcef9b71"
SRC_URI[sha256sum] = "bea8bb8cb70c639dcdce1fd9bea0af975304b9956a3e624141e0fc01670a3853"
