# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c2e85f16017d97dff3e471cbacd30d5"
SRC_URI[sha256sum] = "e1c20316c96e1ab416af921e6feedbd85141bf9704d1a1e1d68a31ba2fceb362"
