# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ca36cdf10ce99456c87a2ba870b8f17"
SRC_URI[sha256sum] = "2696d1957b6e1077b404787891dd7e98d3a04ca1d569c5480f3eef35ec73e8bb"
