# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71a21f0f166154693f280f577166de19"
SRC_URI[sha256sum] = "325b4e8269b18f0d95a5f322c2131527250272cdce22262fce5d5fd164c3758c"
