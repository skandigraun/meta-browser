# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a10d0ef8ccb8a165aa0fa554816f247"
SRC_URI[sha256sum] = "6ac489c980e81dacd77d3b07ed70666b030b8254d56174be869e5ec24c0945aa"
