# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f5097368f0c231fce22bfa511d6fd3a"
SRC_URI[sha256sum] = "8f08fc5221d5930799a5dd9b5baa59d6d279c8377bcb17a47fe2eabb6494bf84"
