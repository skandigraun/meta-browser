# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59aacee33ca89e6cabb008eb5916f7e0"
SRC_URI[sha256sum] = "821ae00b177a2fa63b436e77cac8ad9880486e725ca4004509a3ba576657e09e"
