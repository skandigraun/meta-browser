# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ce01a670537178c0a9fdd8a33cb676d"
SRC_URI[sha256sum] = "6fff451e80020adcc173e62093df6206f174d03931d8d6c06d4d3bac2624642a"
