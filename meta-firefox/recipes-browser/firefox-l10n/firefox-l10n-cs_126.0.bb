# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7351b539cf57949ebd78edc2f99406c6"
SRC_URI[sha256sum] = "3205b066eb40c89f30e7bed9ae2f80acebe6881862b55681823ce592ad4209c7"
