# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42be42cec70ca6d00b1cf452e089c780"
SRC_URI[sha256sum] = "b07ca01c369f8147b91b6296b4d07439ec5f94a5ba0509cf8abc73e4be5ef39d"
