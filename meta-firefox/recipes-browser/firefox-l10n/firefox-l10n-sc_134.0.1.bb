# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e6c7801f1ad1665e7006abe72978883"
SRC_URI[sha256sum] = "4a43d1434d6f2238468bf710af0347bc9f125d3118edc3631f77bde7e61afcc8"
