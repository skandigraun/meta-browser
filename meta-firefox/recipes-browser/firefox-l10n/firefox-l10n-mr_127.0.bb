# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7805033d158acacf861cc8ecfc67a5a"
SRC_URI[sha256sum] = "62ddb7ec3d07ddb566436abf619441a8440788ed6fa20e870bf9048e6e2d67e9"
