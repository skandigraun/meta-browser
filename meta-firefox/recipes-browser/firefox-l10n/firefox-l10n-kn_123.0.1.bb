# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa09fbf961dc013c116d373f9241fd1a"
SRC_URI[sha256sum] = "b60960ea30e493e2e20beb8f400e45ae13497cca789946a2db05acdaf2db4f3d"
