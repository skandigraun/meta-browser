# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5f004142301f42900034d54db43c4fa"
SRC_URI[sha256sum] = "0d0ccbff8863d8ede72056eff7a4d1a244cb5b063e058826e246ae5b4561d36c"
