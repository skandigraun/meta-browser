# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f139371455ddf46f0942b55139aafa07"
SRC_URI[sha256sum] = "df783e634a2db7f2850003ec78168dbbcea9f17802989e867f2153538e98aad9"
