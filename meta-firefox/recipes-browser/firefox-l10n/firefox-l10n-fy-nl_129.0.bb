# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "586fdb9aebfb820208fb1cb3fad84a92"
SRC_URI[sha256sum] = "d073f872cabf6abce95e8dce79c2600cd9980c13eb9d3a9d7ab780be1bd32d9c"
