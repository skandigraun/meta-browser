# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c178f28ee7ed4c3207dcb20ee172876"
SRC_URI[sha256sum] = "ac3782b3641701eda47de603899d15d08fbf7d701c7f08f4e0d3e1999efffa3c"
