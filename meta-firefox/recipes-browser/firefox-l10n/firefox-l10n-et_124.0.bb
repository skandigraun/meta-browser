# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "614b2571d6cc73c9cb14eee82e1b8266"
SRC_URI[sha256sum] = "c80b91f311fd3f17457a44694f1be61d555092c94100af87aa63b116e5bd1888"
