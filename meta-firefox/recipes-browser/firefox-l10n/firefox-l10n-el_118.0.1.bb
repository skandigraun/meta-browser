# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15564c4c036ead593d6fc1efeba39240"
SRC_URI[sha256sum] = "2041ff8b347414d85edb70cbbd6ad9982bc83dc310159dc26e53b719a8c3aa74"
