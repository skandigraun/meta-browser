# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "633971d02a54688cb6060b3e4a4593fa"
SRC_URI[sha256sum] = "9d3b0f8ef8ae97718f02ba9ce5a9522d01a945f66ab9e22c8c726766b9ae790a"
