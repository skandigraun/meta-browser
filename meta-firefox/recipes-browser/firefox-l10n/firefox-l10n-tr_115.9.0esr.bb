# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e83b8f7d7a5d024ada30dafa67425a74"
SRC_URI[sha256sum] = "64986bccf6b9a2ddc4aa91df7b6ccd4e15b351a1477f9081847c5babcc864e13"
