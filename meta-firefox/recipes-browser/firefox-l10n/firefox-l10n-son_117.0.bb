# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4820e6440d1fdb8e9fac78ffe94dfb29"
SRC_URI[sha256sum] = "c09c89c659d376f20823c08dd226b8e3df5df8e3dd939086688d0974522c6d86"
