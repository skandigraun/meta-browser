# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6e79872094d1669929fe1cade71ffc6"
SRC_URI[sha256sum] = "fe36cc6045a92d0f034cb45060ec08a40cc2ef88cef6fa9be6fa69b6bc77c954"
