# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0707f3dbe541f991e95daf1b6c1a5322"
SRC_URI[sha256sum] = "b8f3489e558d0ef544f92b238e90e20aa4dbad06b95c819d20e5b06e8e5ebf4c"
