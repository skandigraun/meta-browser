# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d64da4ff38945dd1d5f5d2a37b851f52"
SRC_URI[sha256sum] = "0822a6dcc84499b69b3360e0c14f1c1760e433eb4cafd8a10382ccabf435e430"
