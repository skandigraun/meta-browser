# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2456b6ca47785fd1ee3bee4d60331ef"
SRC_URI[sha256sum] = "aa56bd371cf1096c65e2c76073d25d69ecc8018be8487e14cac370bd9f5d45b1"
