# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "634c6b8dd27c6cf9ad8b1cab9890fc64"
SRC_URI[sha256sum] = "7f2387fd5c1c1d9c8adde0e6938b3bb0c52dbf97d67ee8a318a5c9e33c2ffeca"
