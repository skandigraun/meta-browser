# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1973b90fcb0648d571ee391e6c24a830"
SRC_URI[sha256sum] = "9cc63b25b5d0bc3375e1f385a9f0dd9c8e6880e092cd6eec5459a96930a1147f"
