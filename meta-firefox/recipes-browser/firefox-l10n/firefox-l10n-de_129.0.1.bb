# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db01f43cf1034a802ce4fe975b5fc8a1"
SRC_URI[sha256sum] = "d30ffd594a73d6b72d457fdc5983810700c430e5d8a500061e45392c4f46c814"
