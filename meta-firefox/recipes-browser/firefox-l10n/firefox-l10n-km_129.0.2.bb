# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aff863c3062e8659622e2b4bd0e5e767"
SRC_URI[sha256sum] = "d0fdceb8c4f78a7c91999fbe177aef8f5603b4862d1980d51169b6e426ebd321"
