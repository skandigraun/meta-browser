# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44d98e3772e55792e187237e6704501f"
SRC_URI[sha256sum] = "f7739111106c6ee2b7f19af615c82a0aa9116f7f4501b9f2087968bcd6d145ca"
