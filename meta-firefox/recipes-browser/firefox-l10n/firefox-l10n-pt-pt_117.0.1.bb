# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a10c8094b7bbae854e478fb195540711"
SRC_URI[sha256sum] = "236c1d847ce594c4657790cac1d11d40fc62e214fe41a501f4eef02c4c4c0355"
