# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d309e245c822d92efd8c5713588936d"
SRC_URI[sha256sum] = "088c0ddfcd406c4946e5193fec2b4749b299f462c1ee488fa48647b379716c3d"
