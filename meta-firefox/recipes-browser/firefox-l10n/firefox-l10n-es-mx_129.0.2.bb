# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6db4ab1f902cea6dbd76d4e8da5354d"
SRC_URI[sha256sum] = "01fce0d94d05b1e7fe643470e92c3f08096c19ce3deab6854181cd01f6541ac0"
