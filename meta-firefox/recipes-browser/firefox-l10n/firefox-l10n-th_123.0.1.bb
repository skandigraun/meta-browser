# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "818c3b0f0f477a44dd12517d1d15222c"
SRC_URI[sha256sum] = "5a95648e2c35a3dcef652b7b2a458b0dab7f092d083666a25ad903a96be1d842"
