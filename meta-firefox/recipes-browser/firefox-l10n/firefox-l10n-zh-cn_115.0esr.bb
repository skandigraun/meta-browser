# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6626d87d09ce97628edbbcf780c6ebb6"
SRC_URI[sha256sum] = "2e692dae54a6b5c3ba8e8c316615e71096aaa352276738b2a841ad9682054c18"
