# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ac9882542d10e9a4537a5f2c0d41cb5"
SRC_URI[sha256sum] = "f5676a7e392671eb459ae816bb986624675271111ac8f30e5facb882e0b95ad3"
