# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df39b09471906ef0a6f4cd5b6230cd52"
SRC_URI[sha256sum] = "aefcfbc7a310a6c8489266683e68c2cc533cd44409507ca014675b704f014c30"
