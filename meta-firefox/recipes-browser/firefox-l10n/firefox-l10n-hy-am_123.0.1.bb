# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "627e48ecbbc527bac852871a3af770e8"
SRC_URI[sha256sum] = "2df5c5b13d0982d502ac5c84a2f09b18ee52342441e53d8cba5cd291639f6573"
