# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "414620119cd7b804a02cc90761ddce16"
SRC_URI[sha256sum] = "391797f9b091ebc425e49a0015949c06fb340ecd17ad14c780d32637f53cce88"
