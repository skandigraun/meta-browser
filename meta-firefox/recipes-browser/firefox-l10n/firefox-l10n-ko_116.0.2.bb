# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff439ec6b04cefc2cc0239dd21b86d72"
SRC_URI[sha256sum] = "0d8475a0419f582bdd27caf8682f965440508156c65e2a1cabfc85490645ffcc"
