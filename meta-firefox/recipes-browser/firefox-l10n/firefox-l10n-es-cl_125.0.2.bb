# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25f6124e657e2b2ae9c0e4ce31f27975"
SRC_URI[sha256sum] = "5b1b29fe2b2daa06296740f690633ad5dfb9e0b37f789748f332bccb5478eb65"
