# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bceb3a2a84a78a40ef97fd2f9a5b88b0"
SRC_URI[sha256sum] = "6f15404bca77866c663e8ba1c727ff40007700ca0d36f0e5559e417e654d3b64"
