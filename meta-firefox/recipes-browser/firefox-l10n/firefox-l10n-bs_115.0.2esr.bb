# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a4d84e58348c792b28b1cf68ba86a8f"
SRC_URI[sha256sum] = "9c0dfe314b1c19b58f7b66a95c704652c61ce52d60d8c554508ddafb9d8f8e2b"
