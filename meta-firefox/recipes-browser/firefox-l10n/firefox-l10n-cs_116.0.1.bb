# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92f1f1e41be1c7da2781cb9c30443a8e"
SRC_URI[sha256sum] = "c6b25f2db25f84968d8d02d76c0f8d613b66661ec52236d51ff8516e151d0aa0"
