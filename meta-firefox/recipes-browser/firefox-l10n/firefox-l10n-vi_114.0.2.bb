# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2ebd56a0b6724e2238382e6f34ce6bc"
SRC_URI[sha256sum] = "54acb4d376eaa2d7c167f12c40155c085a2e1cef647b8f6abcff929ca57e1591"
