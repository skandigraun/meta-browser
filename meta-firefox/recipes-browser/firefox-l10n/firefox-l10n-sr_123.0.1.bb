# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72e0c7429d72d281ce0e0e59bc4aff8f"
SRC_URI[sha256sum] = "a53ce80c656a921bb8b4af73d1ec157f3388b94d4cdb34880e6aab59eef28823"
