# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da053b01cbddb85d553d9e125ca1e453"
SRC_URI[sha256sum] = "985a82d6f8da55c62ab5c64f7b664dce7a41f3e175b67810474b0a840f17490c"
