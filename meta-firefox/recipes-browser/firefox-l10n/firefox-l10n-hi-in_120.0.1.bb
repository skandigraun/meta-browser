# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed4debc5dcb61f070337b25066e722fc"
SRC_URI[sha256sum] = "43cfa0066f6fa92f5ba7b13342ebcd5da3fff4652d5697150e187962b4752811"
