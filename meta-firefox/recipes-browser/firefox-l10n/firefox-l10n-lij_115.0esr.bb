# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "356399f8d9218d219df9998996560212"
SRC_URI[sha256sum] = "1d76c996d02709b98a24075c3033cd9aa6598a8523469417da32d7970ddeaed3"
