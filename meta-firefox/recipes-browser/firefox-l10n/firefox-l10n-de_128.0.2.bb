# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "879c763a1c7e9a30ff9d8fa0429df8b3"
SRC_URI[sha256sum] = "2381fe69b3632b5b482680006e114751d0273dda5453cdcfd50a50a050a770b8"
