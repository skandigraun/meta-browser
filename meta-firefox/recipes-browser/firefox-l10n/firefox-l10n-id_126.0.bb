# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdbede10d2983193cfac243c8ba43756"
SRC_URI[sha256sum] = "2f4aa356e71d80a6721167468995e2696d012970198b04a6d02e14cef7cd3a30"
