# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f74fa4df4484c99ccdc918208a8038"
SRC_URI[sha256sum] = "53dc92bb6947f9e4e11b0654d45076be54923b5d480e4eb3ba285239ae4208f8"
