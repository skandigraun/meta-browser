# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2de78101ad767d4d93007187e02f6f75"
SRC_URI[sha256sum] = "9f6d8658a7bbcaa31194ebb5e4905a35ff49b2a998095231e936d9226272017e"
