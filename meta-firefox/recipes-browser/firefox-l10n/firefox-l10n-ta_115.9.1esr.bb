# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1eec77646a41327b00791ead71d6ad3"
SRC_URI[sha256sum] = "d3e83114854ddd8010471aa0e392b622340842a749acf30a2244b968f0769fb0"
