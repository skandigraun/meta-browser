# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2d7916bb80ac2ab6acb165d05b2ebc4"
SRC_URI[sha256sum] = "2d9c099fbad164d0b2ca03ae4e547c08757820466c8ff4e5a6a7ae2df853a96d"
