# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de9f4ce57b63de8c1f72a3f7988b6417"
SRC_URI[sha256sum] = "c5bfd0fe5b2a003b29624e82b9929ed7ca623829b400bdc2f1cfddd0ce49b2dc"
