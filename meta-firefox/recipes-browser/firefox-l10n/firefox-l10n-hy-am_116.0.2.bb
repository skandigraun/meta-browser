# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d8c0e455a30c608c49398a29d66f7f7"
SRC_URI[sha256sum] = "c0310ff35b2ba65182e1d5776271b5df3478be6f1e69fe9b5196c0b541a074e6"
