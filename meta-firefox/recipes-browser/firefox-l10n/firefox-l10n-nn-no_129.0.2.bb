# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2077e2ee50b11a88b06ea87c71f687ce"
SRC_URI[sha256sum] = "c36db4ec8faaec0b8240f81ce0d0df18f30b9755e75cb8cd0bbff65c08c043e7"
