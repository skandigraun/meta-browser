# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4d703d1017de97ac222fe4c403de676"
SRC_URI[sha256sum] = "f43554639be4a34e788ad565059507e90febd3c74e33760171fab7b6f6feba79"
