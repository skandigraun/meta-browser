# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59cf0b9c27a432153b3dccc9e96be0f8"
SRC_URI[sha256sum] = "1769d9ecc6f5744e3e181239c6f8676aca6452104fc6678c72185ae23b5f05da"
