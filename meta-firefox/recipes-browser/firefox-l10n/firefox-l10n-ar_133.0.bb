# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27cbc4f9a3fca1588991866ebac6eea6"
SRC_URI[sha256sum] = "71f2322480793c0de7779f2536c06c3d4ef857c611943081cb92ac62d0ca7700"
