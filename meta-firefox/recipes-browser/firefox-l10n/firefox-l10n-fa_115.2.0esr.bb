# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e923421f28047a3fef13e4ef3e920ae"
SRC_URI[sha256sum] = "ce5214e0d56a3c6167504dca291414d660aae87ca15b76f4d8a38a7cb8c58b2d"
