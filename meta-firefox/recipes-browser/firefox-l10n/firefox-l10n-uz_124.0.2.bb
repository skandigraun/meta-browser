# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dadb11242b47d0406fce7b0e59c28d1e"
SRC_URI[sha256sum] = "b73b3790ca8af9d4f018fb468eea7379fd606f390cb8fe598f9093ef2edbb0a9"
