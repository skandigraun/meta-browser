# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af9425813a4a74bdaf51eaf9ad2dfdb1"
SRC_URI[sha256sum] = "fe4c44003a92d3187b7b8d9f09d943ee8e61e3332dc7a3d85bd57fb3030e3edf"
