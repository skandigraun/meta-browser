# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89a05fdaf5a42b1c8f3307d1c5cd9109"
SRC_URI[sha256sum] = "adf3bfeaff64a6516f3802625e8f0da3949a68fbce0d76096cb4444136d90878"
