# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b80d68c075a31272197bd7deb391409"
SRC_URI[sha256sum] = "02e2869ed0a77dcda9887e943dff58d0e37fa69ce55fb7828b74b2546bffa615"
