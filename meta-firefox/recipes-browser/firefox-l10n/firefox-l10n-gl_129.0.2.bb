# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88711dad698b7f7b129615c4dc353547"
SRC_URI[sha256sum] = "a15b4156bfdf0659ce63cc30b610a3a183ee0c2a41066215e61f5ac6418c1231"
