# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff0c2441419953c55b78de1dfd6fc15d"
SRC_URI[sha256sum] = "5a79c4840a4beef1c004c74bb3cef471695a5705f23eaacfe18f6a9494abfecc"
