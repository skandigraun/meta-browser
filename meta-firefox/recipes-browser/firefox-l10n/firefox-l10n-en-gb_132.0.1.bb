# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "522ac5f7276961902b499690af2adbf1"
SRC_URI[sha256sum] = "8b71d846dc4aa967e817787401f4143f53391b05d5709e6b0cfc400e3f45c17d"
