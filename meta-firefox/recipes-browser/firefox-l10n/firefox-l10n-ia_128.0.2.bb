# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e91dc9e4863e908763c888f1937ce68c"
SRC_URI[sha256sum] = "be436255c08a749342d24c3a459eb2d7db8118432311b41a1720d370cd9c830f"
