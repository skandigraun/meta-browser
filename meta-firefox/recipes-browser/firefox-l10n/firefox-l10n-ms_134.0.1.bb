# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75111bb1f40f71cb5cdb30bc56029b28"
SRC_URI[sha256sum] = "8b358161a78fa941a2e289d6c5b5c3bb797f4dde9f303b3c3e8933d1e4ff0d96"
