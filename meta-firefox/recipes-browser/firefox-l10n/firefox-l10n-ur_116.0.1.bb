# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1f36fa6e70abb12999d08e3417d4c18"
SRC_URI[sha256sum] = "2574c370c19aa88b07ec8381bd5e413db1323ef480ed75225e4a604f9fbf6bc1"
