# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e57f77e05d9cb5a5a8a8bea045dec218"
SRC_URI[sha256sum] = "6bcc2ce43cdf65c6abf2945a7ddb7d46470b3fdc78c3a65ca96a43bd2bebe825"
