# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eff7445873daa09b218db77d2ef65f26"
SRC_URI[sha256sum] = "15a20d3129cf43dca92b12feff3f3c7da66ecf11f877d9c88d365199f8f785cc"
