# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c94dba7090ead371c184e56653803b20"
SRC_URI[sha256sum] = "aa13450d4027b327ad3cb527876547f5f8212a91c35338d700d12d1be308ee4f"
