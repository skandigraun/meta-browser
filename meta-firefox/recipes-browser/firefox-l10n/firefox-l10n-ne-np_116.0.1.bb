# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c8307fb5c0589adb3c67b6809bb5d69"
SRC_URI[sha256sum] = "2c6cbe58f8eaf030c8af3e80af074d8dd68d1c5887e16d9af5298324744d66af"
