# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5370f470e80aa4304a162e1746672df"
SRC_URI[sha256sum] = "ffb6faa874eff68aa80e98246cbff8743d9e0fb082950e8c2134d243a6a0c75c"
