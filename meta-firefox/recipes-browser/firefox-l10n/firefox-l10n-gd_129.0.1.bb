# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0f154067454dd899f7c8a05e4e89d0a"
SRC_URI[sha256sum] = "76f789db4e3b65199d31ca88217d209370d5291d002c8a19b1b709aefcc30ebb"
