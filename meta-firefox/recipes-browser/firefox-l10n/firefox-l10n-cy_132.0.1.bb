# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7d2468da05e2e64190357b0566ff11e"
SRC_URI[sha256sum] = "f11abc017fab89f1241402556d44f10160986668e8b6c46a47540f43f20bb536"
