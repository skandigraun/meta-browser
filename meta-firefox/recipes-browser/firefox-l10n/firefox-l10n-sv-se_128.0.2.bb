# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9d9ca48186105ba3373f62706ada5f4"
SRC_URI[sha256sum] = "ad416060fa5fcb60193ddc1d6517d2356907383ad941108b2cb34af38ca7898c"
