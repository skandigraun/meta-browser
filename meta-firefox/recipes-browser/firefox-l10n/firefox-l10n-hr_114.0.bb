# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94f2efdf1378967edfec571bb6296a2b"
SRC_URI[sha256sum] = "8968f1a77e30680209df33cc6282797ef0e24164ca65141e232d8bc3fbff8123"
