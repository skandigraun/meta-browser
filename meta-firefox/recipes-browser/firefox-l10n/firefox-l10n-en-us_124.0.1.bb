# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "814959041d2975986a22ce743b6b5955"
SRC_URI[sha256sum] = "3d2fd438791f685372dea573c8adef0748167d6be8a655a215b6fc920e99e604"
