# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd6e9cda2fe297767119c54b2f24b65a"
SRC_URI[sha256sum] = "670e141a0662af08a70a3137883a0db33cf498b603ae36f7d5be4e9a98d52d66"
