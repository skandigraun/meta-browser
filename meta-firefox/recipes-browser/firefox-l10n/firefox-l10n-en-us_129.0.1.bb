# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b5750cb18725b6210d134427c3e4081"
SRC_URI[sha256sum] = "16e30366e2f38d3b2681f9dbeed274dd784a1f41467d9f80e07649bd12511a9c"
