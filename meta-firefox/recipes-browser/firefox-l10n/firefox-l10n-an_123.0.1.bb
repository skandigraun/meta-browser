# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd183a250521cef7b1d3ea76d336807c"
SRC_URI[sha256sum] = "afc3d67d3e0003e232464f7c6321ba8ab2e3ac4514b922415ed919ef0980e8b4"
