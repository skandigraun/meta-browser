# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48d74b386debf262a4f1c00cd3074b8b"
SRC_URI[sha256sum] = "37296510fca362d7cdeffb26114f92c5fe23de5fdb90c3d1315b18c25bf672f0"
