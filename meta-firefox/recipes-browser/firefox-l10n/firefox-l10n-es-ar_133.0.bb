# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "420085b21d8e44dbabd317afe4c5daa0"
SRC_URI[sha256sum] = "0c6e46938f662fb39bda85d68d9131f900aa062a0ab6250bd5c61c9f67000502"
