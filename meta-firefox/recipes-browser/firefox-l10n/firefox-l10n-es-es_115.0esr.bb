# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6048f7c34ceda4619a54d169b3bc88ed"
SRC_URI[sha256sum] = "f0d1fb7aacb2dc610167e0971e8a5217504cc0933f900538ebe5c2cc92d67b9e"
