# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "499b9551518f06c361f0a0bdf01a22e7"
SRC_URI[sha256sum] = "75ba6a801bab8053b97249b9018747afb7eb804b6417e8bea3d32a8017f33d9d"
