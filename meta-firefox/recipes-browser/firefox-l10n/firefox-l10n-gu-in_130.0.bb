# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a76436ab197ab61c4b7060f7f3c29b"
SRC_URI[sha256sum] = "b2f4f7a37d17203c49a3ea7d60f3be058e9394ef8d60fded2c574ad10833c538"
