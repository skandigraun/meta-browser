# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46d2a0d3ccf6a222fd8af51978eac90a"
SRC_URI[sha256sum] = "eefea3bff6d683f1752ce4451e30f5c04a273b35211b4c38401d036efe785bbf"
