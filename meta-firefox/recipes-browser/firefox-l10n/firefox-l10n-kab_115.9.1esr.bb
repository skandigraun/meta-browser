# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1226d054196862b51dbe42ae6f2be70"
SRC_URI[sha256sum] = "6bfdba6b4c4a6c968396e8e2c0c663c47f47ee018f0609dd90dd30c47c98c697"
