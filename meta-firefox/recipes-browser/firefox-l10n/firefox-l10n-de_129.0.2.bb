# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0239ec405e88042a60167e6d0d7be55a"
SRC_URI[sha256sum] = "79c30b4af8c9671789a7e8881a16aa0529ecacf88dd5102dfa89181f5d4c5131"
