# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7819b5964934e2d10231940cc7a3d3b"
SRC_URI[sha256sum] = "26a25f040c7900e80c65de444f8ef2bceae03837840c40fb78d0bc9fcf0c64b2"
