# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "407e563858339fd17ace896125e4cfb2"
SRC_URI[sha256sum] = "9f211c1c860a4200894712f80a32ffafefd4e118458e1f693f05823b23a31540"
