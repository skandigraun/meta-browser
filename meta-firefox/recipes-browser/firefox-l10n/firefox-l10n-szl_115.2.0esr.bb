# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44f8356c87d3be401eddcdee06e17b66"
SRC_URI[sha256sum] = "d01d3fcb1812f2bec3e13102e3f361d3462d2aa07a6a7a4b5b5871d2c6687fc7"
