# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdf63f42017fc2957e201e2ea164c6f2"
SRC_URI[sha256sum] = "ca0150e10ba6cc157f19c33f840dadb3e39c7e64c2add742d7738b507ea5e8e5"
