# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c57cb197b3ce75e8fada315abac52f03"
SRC_URI[sha256sum] = "8ca6ee18ae92d36bced998ae72247b868335deddea0048cc8003b1f19c641b75"
