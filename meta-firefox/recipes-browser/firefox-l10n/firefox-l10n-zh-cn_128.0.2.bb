# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "210770c5beeb22893059d7da18a90fbc"
SRC_URI[sha256sum] = "c4776284a017ba9d0db50377b8e0f76fc7e8ad7a17d1c65077ff291e5585dc05"
