# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c20afeb7412eea34257d2b0bcbac0a9d"
SRC_URI[sha256sum] = "b0acd2a0ed7879944d6300f4a1c8545b10043ea48580133e6a1233e90a87b83a"
