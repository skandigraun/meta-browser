# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b6bd58f66ebf105b1d06796f46b19d"
SRC_URI[sha256sum] = "46f49eb2de631bd63e7a22d97a1c0512e89d69b4dc9fca9d0bb8bfddd78c94f5"
