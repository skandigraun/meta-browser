# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "385bd2f00651d67e6993468108463357"
SRC_URI[sha256sum] = "33f1b747604a52299ceebf554db6e724ce5eb37b059eb8605363fccbf64fda50"
