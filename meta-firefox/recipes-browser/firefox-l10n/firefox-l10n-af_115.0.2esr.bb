# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0887b0d3f544d27c2b445c2670494ea6"
SRC_URI[sha256sum] = "7e1b92e6c88170378c8ae99218b0a47ae0f65c4924d8364292f581f6e8d13b12"
