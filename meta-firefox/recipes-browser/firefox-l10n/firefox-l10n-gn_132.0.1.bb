# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca049975cc14580f8ceb1cbba37eba39"
SRC_URI[sha256sum] = "7b4664361fe80984183dcf53f1465cd8e325902b55368e7e7046ca08e51768ac"
