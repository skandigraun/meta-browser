# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d27012101a8d7e2dfe135bfe6c8f4a5"
SRC_URI[sha256sum] = "03ce9ce01adda6d8ec25c464dbd83626e05af93fdb42068f2f6cddff9bf4ebeb"
