# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a0d28453a22694e37e5a2230695098e"
SRC_URI[sha256sum] = "6c79decb629356fb3ad62a5334085b7e960c207b6140a3e6ab7cded203a02b4f"
