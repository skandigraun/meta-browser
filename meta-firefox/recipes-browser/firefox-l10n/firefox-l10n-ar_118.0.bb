# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0126be9fd9ccd67eed1a30c4a5ebb4a"
SRC_URI[sha256sum] = "a82e7b1a07fcfbf480b31c04f4ae204574c53f96dcffd0704ec66ccd4ad1c4bf"
