# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f75fb84cc88362fe102fed1cfd974c30"
SRC_URI[sha256sum] = "9b96af29970e19b8cc87b4cc5fe2a8e6347962b555d64747b5a01919af67f0ba"
