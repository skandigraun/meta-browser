# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "facace59cd6be0a84452327fb153110f"
SRC_URI[sha256sum] = "e3cbdf9578ee7f6a8dd6ef0a504dfb2015c9b26ff487e2ae6657744cd608adc8"
