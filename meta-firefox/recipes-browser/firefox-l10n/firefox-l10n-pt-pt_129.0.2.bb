# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "177dc58ad6b84c4456fbef3330296133"
SRC_URI[sha256sum] = "1de2fe4f1e7e06a617525881ddf54850de30fb1646bd3fba46be4ae57e26f53d"
