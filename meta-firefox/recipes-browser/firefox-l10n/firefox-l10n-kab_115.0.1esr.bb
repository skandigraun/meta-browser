# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "184f4f730349ccf52058715dc19a5119"
SRC_URI[sha256sum] = "1a15498b1484d26e3c460745f2baf2ff365170b133bd25bc72199fd77d6389a6"
