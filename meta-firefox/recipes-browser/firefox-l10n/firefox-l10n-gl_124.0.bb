# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da558a43893b6366d4206e14f6c59943"
SRC_URI[sha256sum] = "98f0d4e5d4d9b2fc33805746b73d6882fdab8b24944f62dc9c75bea4af4cc852"
