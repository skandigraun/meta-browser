# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f99b746121cd3bef5020f0638911958"
SRC_URI[sha256sum] = "b80257613edea11b0347201a2861b600c8b483d54f23863e711152add18f5962"
