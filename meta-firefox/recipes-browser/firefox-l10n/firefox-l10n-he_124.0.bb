# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f08b4220bf3af5d964d63bd4b45dcf9a"
SRC_URI[sha256sum] = "6585fa856ea6ce9fd83ebd643bf1586ab0d1cc12ae0b3136917ff444dfd6027c"
