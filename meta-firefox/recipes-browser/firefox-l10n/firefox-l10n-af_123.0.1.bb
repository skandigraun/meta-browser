# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1054fd8ac5873d2c93309ced31f1b4c9"
SRC_URI[sha256sum] = "3c1202a5f1b0a8408aba55ab76c42548762277f9f12783531d69b78ad4b3db1e"
