# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b170cc4d142f7978ce6022e6f4b91dce"
SRC_URI[sha256sum] = "c52d48273d34adb2c2d083dde2f52388d365776409dd53ba6d367944b0d00a8b"
