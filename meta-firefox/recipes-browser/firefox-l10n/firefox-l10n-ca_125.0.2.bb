# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "267617a79c8ab7390b7c19f6fba293d2"
SRC_URI[sha256sum] = "3d973a77cd0013752fdaf31e9c54fc6d2e9f02fddfc195f6025317bc4436231b"
