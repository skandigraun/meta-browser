# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d9b9dbd3c5ff5595f3d54e749c8717f"
SRC_URI[sha256sum] = "b9e89d26388285e5039a68db2e3ff4628268d2617de362d8f0356c7971fc5e04"
