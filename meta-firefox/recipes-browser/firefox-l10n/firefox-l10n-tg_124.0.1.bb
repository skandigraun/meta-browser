# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7ff395b8b05e8d93f2f66622938f602"
SRC_URI[sha256sum] = "72cbc99d31908516cf9a52d5b28a955931275160f0b860d2c08225a4ab07cf90"
