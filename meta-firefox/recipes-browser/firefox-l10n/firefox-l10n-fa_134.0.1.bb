# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9ca514e1c2cc6245f47fc0f14cf56dc"
SRC_URI[sha256sum] = "d04fdab0637ff9cb342bd60b75c9e068bc56fc472428a29c6dab492c16699781"
