# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "499923163632bfab089d4d239b701362"
SRC_URI[sha256sum] = "2c475638875898d9aac217a434759d867e626fb1e5d5318fabc4a936704f3913"
