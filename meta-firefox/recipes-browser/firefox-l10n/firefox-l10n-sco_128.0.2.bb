# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab60f9a6b5655dc41ae49034c1bbaf0"
SRC_URI[sha256sum] = "598d20ffa58ff29bf91ff1f7c86656a16531c8820dc56b604d13a78c13dad37c"
