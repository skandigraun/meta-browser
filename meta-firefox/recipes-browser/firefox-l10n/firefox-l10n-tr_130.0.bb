# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b8395aae059a3e864bf7c4707773e2"
SRC_URI[sha256sum] = "51ce629ff47cc3ae0d45af859c2aaaf8d2d0376b1ccaf5264e907e72500d8527"
