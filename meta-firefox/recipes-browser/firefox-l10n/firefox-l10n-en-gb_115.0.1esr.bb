# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a108623c9b4d4495c6c803e7f6e1ece1"
SRC_URI[sha256sum] = "2cb1c713719f5737e80e8d1aab2df0527a75a07f5954e6f39538d750892b5241"
