# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "383f591fab2881bfd79293931864cbf5"
SRC_URI[sha256sum] = "7b236e52cacad43b63bf5655fd1e98acd457c5c7c83a124968adc2dcffefebcc"
