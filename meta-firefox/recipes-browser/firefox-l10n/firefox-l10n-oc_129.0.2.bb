# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81f5829edc016bded20560fadc4c1c67"
SRC_URI[sha256sum] = "3fbf77feed7b5e9f1f7e7e39fb0162278ddac2b097f229144f4ccef16f3faa39"
