# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ce39de2db5a7f8c668be6c1f46dc639"
SRC_URI[sha256sum] = "034d2b25487ee0cafc48acef02e70da1145d08a58428e90b2f87c32b4758998d"
