# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d9e1f2a30630badeb3de24d6dffcaae"
SRC_URI[sha256sum] = "ef9696a5ba577e81fbd8fb38bdcaa00598e6edefb695f3f305e266d972354078"
