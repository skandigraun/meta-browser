# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd9edd57a0f5d425394c1371026da88e"
SRC_URI[sha256sum] = "09f6f67a5983be4d9892770e351fe9b79404bdc7be90d78190795adf08dbc232"
