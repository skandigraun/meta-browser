# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6c94775399203577880caebdf3222c4"
SRC_URI[sha256sum] = "fc5dea5c640a0c97cf5446d69ded43efec99dc4d2817dd956643dc5407cf8c84"
