# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cda811b0a82219e2400cbf428a44914e"
SRC_URI[sha256sum] = "0734009723dae36581c9d4b3556ebf1bbdbe257aa3a916d0f1826f9a462d50b7"
