# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e6ed3bfba470517d839f5bd36d4323d"
SRC_URI[sha256sum] = "fd7b2b03ec9510dd24928f4eb36578583aca0ce8517d88ac7d3ac8ed0da7351c"
