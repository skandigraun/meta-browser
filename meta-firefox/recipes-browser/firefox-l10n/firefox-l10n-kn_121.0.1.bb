# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea759efa790d081c4a8c54e68683c216"
SRC_URI[sha256sum] = "748a51f10ce3964550ef8fa44faa61bf622fa591f4161eb30026599caa0a9ce8"
