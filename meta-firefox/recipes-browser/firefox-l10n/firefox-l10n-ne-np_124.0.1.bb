# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de6a31db8c1911aab679ca1d9d5ccd1d"
SRC_URI[sha256sum] = "5cbced6305e01a635d41d9401756477e95c45927a705939df53bb7a349cc4131"
