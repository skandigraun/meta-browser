# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8037307cf00a93d7c89f2256d005e3c2"
SRC_URI[sha256sum] = "7dd0039ea63cf64946ec6599374d08188fe75bd350c3a48c3ba752fbf4350377"
