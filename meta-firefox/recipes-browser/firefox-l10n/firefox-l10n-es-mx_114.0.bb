# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3e7ba8cce1f919832a1aa4d7245ba9a"
SRC_URI[sha256sum] = "a28453e1d0727297918fb3a83bd68090598c5ddd0386e5cbd21b5ead68cd8d2e"
