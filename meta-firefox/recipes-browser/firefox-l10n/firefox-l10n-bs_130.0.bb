# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4efaa5133fe78744b3ffa4dc9810477"
SRC_URI[sha256sum] = "17a229fc8d88922c910fba521fe8411d2aee147319b0662763a07c926255cfbf"
