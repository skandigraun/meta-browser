# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3c54bab272201f248f33e57c8d05bfb"
SRC_URI[sha256sum] = "fe8c3e07c1efb44f57f0c34e29a96eb01531851ec1e4d8f6deb133e894174749"
