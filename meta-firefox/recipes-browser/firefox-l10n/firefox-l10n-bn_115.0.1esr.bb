# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dadb237a0950093ad7bd643536999aba"
SRC_URI[sha256sum] = "763217268fc25a60e78599f7de418832bb9377730024df8108a1dfa7e2884cf0"
