# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9da4d30facfe3a9d6e138ddbd44b50b3"
SRC_URI[sha256sum] = "40d4a74c94ea2020aa032e55ef00b10d9b23f04a5f48aa46fb4c195245c96265"
