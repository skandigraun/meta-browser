# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d224fbc459a6ae6cedcaa1042fcac5f"
SRC_URI[sha256sum] = "1754b91fdd930fc46119a0cd8bdc9cef26d0cde83f144fc874946819104441c7"
