# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35ef6eb988a1afe53c969a82277e35c7"
SRC_URI[sha256sum] = "54590c2aad238c4eaac7a83859f441cb9736c136cc2facda1518a2445cd28556"
