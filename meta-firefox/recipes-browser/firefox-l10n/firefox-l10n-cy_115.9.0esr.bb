# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0586883d09bb4da5055348f516bf404"
SRC_URI[sha256sum] = "b615ab5ecb27d73891fae88cf5a6d9ceeb1c532805de9aed307e43a334a73a04"
