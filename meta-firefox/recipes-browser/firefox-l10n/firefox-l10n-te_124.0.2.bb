# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70e94b190d754f6f594d6739acdfcb1d"
SRC_URI[sha256sum] = "2cdc6063579a11fcb3dd73b0a8a74da287fd2ed0cb2fae4add9a488934a71396"
