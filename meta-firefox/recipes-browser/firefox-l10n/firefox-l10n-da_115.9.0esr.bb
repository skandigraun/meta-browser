# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b650f3c747cc9c072b8552cf5767a2c0"
SRC_URI[sha256sum] = "bfd646fdc7b5f56253f7423783fce213d9b43bb0776d1d0285106153512f6a6e"
