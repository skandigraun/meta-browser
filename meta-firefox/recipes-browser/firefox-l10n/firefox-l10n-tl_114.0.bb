# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae546d8b820ccd3a809e0ad808320abb"
SRC_URI[sha256sum] = "0a48ee5ae79e98d8b07adfef4eaacf93b19011ec3a667bfca3fc0098e348ab8c"
