# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c40dfd0e64efade1bb75f1f2c23ac29"
SRC_URI[sha256sum] = "c88180f9b650208f1c236fa101d8b80191006e2a86e2f6ed51eaa9af89688adb"
