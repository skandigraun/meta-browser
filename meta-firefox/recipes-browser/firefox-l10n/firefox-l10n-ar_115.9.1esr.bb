# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25644654912d6adc5f61ed4f214b58d8"
SRC_URI[sha256sum] = "81e327444f009bc23d21fe5cc82fd033278ef5c8ce2091b35ab5489bea65910f"
