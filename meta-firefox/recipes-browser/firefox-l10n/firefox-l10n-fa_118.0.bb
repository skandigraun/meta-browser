# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c58a92e9124c56d337041ee70ffa9ba"
SRC_URI[sha256sum] = "278ffae5befbe7ad3847fd06c98480f58001c52f781b66aa204fe121b318841c"
