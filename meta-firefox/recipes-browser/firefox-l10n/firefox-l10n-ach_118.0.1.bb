# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c37a8f2791c5d3b31582852814bde603"
SRC_URI[sha256sum] = "acb006b0d126b49ce1921ae0fc8ca5f2e55d026a27169efc262b94a0b72b7541"
