# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "237a8067e84c500e937a9a738e7f3b9b"
SRC_URI[sha256sum] = "65e896be75e84826220dc05d3a5a30f58949993eeea25ef25657162c1cec8d3f"
