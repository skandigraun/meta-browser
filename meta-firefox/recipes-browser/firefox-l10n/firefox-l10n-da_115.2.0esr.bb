# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1feb0415436b9809b9388e858ecbaed8"
SRC_URI[sha256sum] = "bcf99de5c390b04d75ed31575537dabf4eea9732585b2f8c2a39e31d00c1460f"
