# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "918cb3046a718744bdb049257d2ae4ea"
SRC_URI[sha256sum] = "ca6783db9f19301cd3315593ce087e21065eee8f267882243e59e55a4c50ecc8"
