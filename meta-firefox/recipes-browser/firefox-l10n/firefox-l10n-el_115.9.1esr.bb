# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce155c1e2757bf03c11c113b8fa444c9"
SRC_URI[sha256sum] = "6b3b566a08a3a8d4658f9fed52c5e3ce5a343824f8beade767685be414ee5e93"
