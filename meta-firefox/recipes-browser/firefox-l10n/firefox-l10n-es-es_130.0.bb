# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd7f5744db3689735a96523c918492eb"
SRC_URI[sha256sum] = "52a94e600ab25e67641f24176563d2d5a78c71772d58879b0a99f84fcdd8fd5c"
