# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3eb714d57464678d5406fe29e0bc8dc"
SRC_URI[sha256sum] = "c318cd7979e89211ddff5951a1c96ac0604f2d54fdfa4e4748ae217ec062d167"
