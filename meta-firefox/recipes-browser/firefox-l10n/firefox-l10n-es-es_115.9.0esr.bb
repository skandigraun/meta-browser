# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "731497a99196fd2be90f99d8cd3bc29c"
SRC_URI[sha256sum] = "d65618400c7479a67ca25fd3b55a4bfd1d3f73ba4da8dc908a7ee3cf93ded51c"
