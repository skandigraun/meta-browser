# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74501cf68f1f9e20c3ec4ba02594119f"
SRC_URI[sha256sum] = "f62b3c29916f6e63c86e01c8838baf5738e435c966cb1defaa75967bdd4877a9"
