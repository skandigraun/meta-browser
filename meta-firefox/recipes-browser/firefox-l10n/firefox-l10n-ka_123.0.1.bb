# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bb8d67a911e9b687eba2cff387b8306"
SRC_URI[sha256sum] = "aecb5f898cd977b5608843395dd7749a179951b3fcb53bd5bfcc69dcdc2e0c65"
