# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03f00fd2d84786fdccdeb1af044b8671"
SRC_URI[sha256sum] = "c286b0c89ffe6ea97fefc8516364d9067d4dcf32945f37aa99ac0b27d0a8ebe4"
