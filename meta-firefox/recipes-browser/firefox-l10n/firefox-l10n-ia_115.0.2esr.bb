# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "559effc1e20d0d141b3abbeeafb079cf"
SRC_URI[sha256sum] = "e5926239a0cacba25ecc5c3694db54b8ad691e92a5ef4f2463e9ec1a984ec1ae"
