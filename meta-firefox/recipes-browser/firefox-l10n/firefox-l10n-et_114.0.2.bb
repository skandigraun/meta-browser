# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "879f6d55d2fddd7e4615ca3f40fc67f1"
SRC_URI[sha256sum] = "5080350e2536bca3e658432a015b8ed43049ae975a49e9320a2a6eca80fdadb1"
