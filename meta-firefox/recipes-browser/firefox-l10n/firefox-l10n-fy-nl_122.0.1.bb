# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e27112a056d19b47946d80bdf26e8d1a"
SRC_URI[sha256sum] = "1c624963c887cb599669a82854cc3062a80e24b85a5c1f0c09a2b95be6f74c50"
