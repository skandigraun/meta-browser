# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cb7d17f721a803de79b3b06f0cc8513"
SRC_URI[sha256sum] = "82e4f73e7ff964770544bd4ed70d66abed042bf4a1d2780aab67267131130cf7"
