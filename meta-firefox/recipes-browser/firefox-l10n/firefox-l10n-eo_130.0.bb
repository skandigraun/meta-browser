# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89d33d6e8c0cf08891e7eb7b2ff8142"
SRC_URI[sha256sum] = "7c3a17fe462fc6cfabc162c07768df54dae5ed54107c373cd2b0a7727c9787b5"
