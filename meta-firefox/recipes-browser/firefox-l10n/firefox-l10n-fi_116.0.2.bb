# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "221f5947f7a4cc8b8f4f548792de4c1a"
SRC_URI[sha256sum] = "8865dc80eadc3ff36b22dbdfe1aad1217a1a896cc821607d8350a03c8878ced1"
