# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59e5205d833145be3317b4c869226a44"
SRC_URI[sha256sum] = "753fba6cb18d67e598f5be5b80fbb26cba3b4ff6054c877997405dc59eaff073"
