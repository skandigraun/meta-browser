# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7efa4ab4aa08a4991f7da3c90199090"
SRC_URI[sha256sum] = "97f857bde31b2974737bc29c43bdb30e7f38fecc8b1f3ecf3eefe1d407027ea8"
