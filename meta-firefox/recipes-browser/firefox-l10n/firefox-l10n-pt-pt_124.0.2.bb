# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6189a8703d1f05df6c84fb6fc94f2006"
SRC_URI[sha256sum] = "31969d41b33934a9ef5cd18b0367e6437e9ddc6ad59573d857dc72aa0a0cfe12"
