# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17536e11147e0e59dfaf1c47358f3c64"
SRC_URI[sha256sum] = "1b04e8f997d679a5bd28fef257b2ecc4069a43e77ed668b1522a1fae8354650f"
