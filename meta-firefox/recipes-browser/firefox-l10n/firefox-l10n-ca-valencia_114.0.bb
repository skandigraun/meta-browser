# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f447fcea389891300c392fb50bf31b4"
SRC_URI[sha256sum] = "559b6c47830caaae13ea507cec2268e4469ee1b90504cdfa1252e5d6295d9a7c"
