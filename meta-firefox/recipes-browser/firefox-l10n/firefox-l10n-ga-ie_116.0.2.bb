# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eea54266d63171bd3c1615020d304ffe"
SRC_URI[sha256sum] = "ebb013e64c1a01402d54d016ce383eab67f65aaea7e4509479d95be631c2de54"
