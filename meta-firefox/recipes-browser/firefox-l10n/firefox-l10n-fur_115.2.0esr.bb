# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5734d8768dbc55ba23e601d825070fa4"
SRC_URI[sha256sum] = "e157ab3de59cfd10f5b2d358d6bacc9f917a48727204e322e6cacc43f44ff755"
