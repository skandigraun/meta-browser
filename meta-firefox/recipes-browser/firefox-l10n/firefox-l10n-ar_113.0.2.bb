# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "638c83d26e8cf73442219c638a09c15b"
SRC_URI[sha256sum] = "2a58abe3782baf8189a6d840cb70dc15c9e33b793edd9a300a80b275001d980a"
