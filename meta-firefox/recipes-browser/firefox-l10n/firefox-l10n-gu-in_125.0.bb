# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ab1b05780b5feb8ec9ec2b0d16068a5"
SRC_URI[sha256sum] = "1e416c7fee9544e39b6d3fab023ddb56e475dd17c790d0f0d1226a221a3de75e"
