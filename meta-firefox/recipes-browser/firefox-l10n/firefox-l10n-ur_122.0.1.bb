# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46918b995b1dea446ce8d608f5c37d00"
SRC_URI[sha256sum] = "227c2b524d47b8f2f59185160538d37455e913406d6cedee6762df307104c9fe"
