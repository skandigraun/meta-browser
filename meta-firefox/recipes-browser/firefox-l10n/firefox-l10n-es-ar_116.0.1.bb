# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16b3e46a101d4aa5fb575e37f27d7f14"
SRC_URI[sha256sum] = "f75a09872f2d9ac42ac098ba456aa9b9f2b396258fde0a40fd8db3e5c0fca3fc"
