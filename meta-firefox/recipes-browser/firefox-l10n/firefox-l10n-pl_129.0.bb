# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8652943ef40e74d871bbfbcae5018957"
SRC_URI[sha256sum] = "e6a8f61a61e73ac4dc439d0c6403a7a63ebaafc06c22831143c23e8bc4b0b9f1"
