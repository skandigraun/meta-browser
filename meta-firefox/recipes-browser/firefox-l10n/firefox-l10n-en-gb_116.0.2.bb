# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46dfb525d0c0b4d8b84a3ba67b308bde"
SRC_URI[sha256sum] = "1d1df402afad3088dcacfe4d8bfe6753ac78e40f9edeea10764a57ab41a569c1"
