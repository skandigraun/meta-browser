# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17363f9f0a0ef382d817c70258ca5e38"
SRC_URI[sha256sum] = "6aa456340b90d17b7c2c92abee7d7c579b9baadc5d925040e8f5a84de893f2a4"
