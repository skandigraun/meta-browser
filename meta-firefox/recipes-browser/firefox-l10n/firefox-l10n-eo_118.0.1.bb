# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae71e8656e2cfd4667eee5aa09569cc5"
SRC_URI[sha256sum] = "954c040e5b817cd8737e3e894a889baf4ef5fbf9ea1b19fc4998501bdf6f7f06"
