# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45bc6603a9e4f8d93d830ada072466fc"
SRC_URI[sha256sum] = "984580c3d082b8fe79ed6ffcda5c68a6787d4f4572b5c2118e902dedb8e1cf47"
