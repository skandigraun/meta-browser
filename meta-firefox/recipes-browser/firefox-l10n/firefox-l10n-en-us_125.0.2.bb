# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a9263e4b57e88d9448f685f0f9ff89b"
SRC_URI[sha256sum] = "041321d78cc68c8b4be21a84ab8c99508fe9e50286f3a1b2665b22ecddb851fc"
