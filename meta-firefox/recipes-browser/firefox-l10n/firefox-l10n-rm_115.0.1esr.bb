# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "632993203fbdb352ee0c28ea87abf4b8"
SRC_URI[sha256sum] = "de6371e6c0186ceffa08d110265f3b843061fc9c3b998e3d7addb47545f1dab5"
