# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7fdcfbd8d64749fffe9fc67e14cb78b"
SRC_URI[sha256sum] = "8fd5d3e30d186713e7e5781d47402d61b1b3d7fb85dc1690dc14f072ff186045"
