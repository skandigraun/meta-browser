# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36e0bb3d98346ffb66bc05547cb2e238"
SRC_URI[sha256sum] = "b75282939fe8744afa54fdb1c20528e515a85d10238cdbe7a358e274d3f162a4"
