# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d99c7048468d6ed7e337e4e10ddf0a5"
SRC_URI[sha256sum] = "3bd2717a5e9cc7397b9515a8a44d4f2e75f2d28c01dd39c4b8bffb46883446d3"
