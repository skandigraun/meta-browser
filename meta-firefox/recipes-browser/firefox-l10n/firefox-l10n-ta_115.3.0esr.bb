# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1de17a37d6c701230a24e07a95372cf4"
SRC_URI[sha256sum] = "c3ce4625edafd8650cef3f719cedd5446b9fbce06211241a2289e63633baaf90"
