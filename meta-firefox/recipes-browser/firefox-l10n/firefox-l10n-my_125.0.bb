# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59ae85e12cc060ace34e7eab064d8950"
SRC_URI[sha256sum] = "cee072cdafd2645cdc44d559c3c1170b5a05e4680620d5da4f7bd927d2c245cd"
