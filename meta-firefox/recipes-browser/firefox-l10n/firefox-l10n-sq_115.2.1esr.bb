# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31f9cd6f29f84f57937f2bcb5c750e96"
SRC_URI[sha256sum] = "8dbbfa33c021a1d218089fdcf3f3c09ef9022207203d68ea89efb8c83c23c7f3"
