# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9119e6857215bc1aa59cc9aecb867a7d"
SRC_URI[sha256sum] = "b56d259b94bdd39408073b22b3d290aa6a72d9948ec096ede5d2dab48ba4a32e"
