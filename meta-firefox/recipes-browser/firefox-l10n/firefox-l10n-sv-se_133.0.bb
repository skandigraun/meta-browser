# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09455780d5b927996cff655b64de5a1e"
SRC_URI[sha256sum] = "ffdcd35c90d0711b6f5cc51ace4ac62414cc08ff6a2981d093973ac1b7326cad"
