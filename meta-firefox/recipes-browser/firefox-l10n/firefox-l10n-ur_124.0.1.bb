# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "442dfcd14e3af5b870058294596dae5c"
SRC_URI[sha256sum] = "602045647342f4d374046f435087ec55e3541e1ec801b15320b9b668533ed33b"
