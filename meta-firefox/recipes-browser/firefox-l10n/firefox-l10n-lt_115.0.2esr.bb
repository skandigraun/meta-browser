# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e016653c99064df76688188d89bf3d34"
SRC_URI[sha256sum] = "ad38c245b19e6d92a88bea2371799447588f8d6f6dfa8a0e76ff694410b6628b"
