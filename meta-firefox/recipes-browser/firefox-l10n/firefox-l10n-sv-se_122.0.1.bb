# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde57b50d1473900ff9fda8f14816df7"
SRC_URI[sha256sum] = "a48029531fadabdfb4ddd5c1c9f25056e62e9fd0d1ec3b21bc2ae6d3fa1412f0"
