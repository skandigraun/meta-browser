# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f71951b905d19f4219215a0ba511fc2c"
SRC_URI[sha256sum] = "774430d2de5f6e4dcdb2c7054d8560fa7ffb90216a2ad2d177526dfb0e5daa81"
