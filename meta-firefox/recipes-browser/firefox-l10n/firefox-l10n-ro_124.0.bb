# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7a8204c1b931760f3129a042fd1d63f"
SRC_URI[sha256sum] = "2a38fb0f335b99adcbc821fb5188ff2f33b47e21f541b42710e0ad20498ef9ab"
