# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d6935f0503049adeccc7363fc9b6c59"
SRC_URI[sha256sum] = "6cd5dbced28ec9097c18a6737ecf1a79722cf499df56298f7241a099a3c0ba3a"
