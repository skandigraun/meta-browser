# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eed11aeb2714230ee8f1695f1607107c"
SRC_URI[sha256sum] = "c0f87d093a839840ed54dda39a4799a2cc42262223e21bf45be9f2f53b04b45a"
