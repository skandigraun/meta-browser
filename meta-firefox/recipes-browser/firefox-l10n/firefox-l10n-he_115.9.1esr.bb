# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c397f8f11c74260f2117e8fbe3d33645"
SRC_URI[sha256sum] = "4b9515c1cf5c96daa4280f2790026bc9294e3b5a88a1c61bd09b7aff844554e6"
