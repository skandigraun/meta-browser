# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4927efc290872124987147f456d11c3"
SRC_URI[sha256sum] = "12881746ebf1de0858ba48396408eba4096fc3769dab0974663e766ec9279a04"
