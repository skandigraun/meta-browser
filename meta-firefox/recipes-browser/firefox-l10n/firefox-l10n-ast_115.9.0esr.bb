# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b130a808fa8e515fc75520194369eb91"
SRC_URI[sha256sum] = "3e86e39ebdf42189c9ebe436d756dbea7862e14338117b0aa53b6698047b0c6e"
