# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccca23e645b1c22c2d5e092c75446b90"
SRC_URI[sha256sum] = "ca1fd8d8174138bf46a6230ce1643c6efd4d529e323ee6db65d722e24d19d9d5"
