# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "483dd1b28c76367eeee9a40b14599fe5"
SRC_URI[sha256sum] = "2cb0e1292a76b0557eebbed6606ad2b045e0b16bf16ae7863306e8e4f066e4b9"
