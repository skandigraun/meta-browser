# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "250d921916e848522d7aefa16f87780f"
SRC_URI[sha256sum] = "d2bc255ba016961fb77af9f29c9b7a5f6883ee25ed46d1c0913a0931e0f04b2a"
