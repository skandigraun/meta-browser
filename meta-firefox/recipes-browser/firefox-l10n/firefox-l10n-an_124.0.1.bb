# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b51f79f668a9a13d60177555e9c5f7c"
SRC_URI[sha256sum] = "5100a6707c6fe9f90385c664535823a725bf646ac2805b582799233ce228a093"
