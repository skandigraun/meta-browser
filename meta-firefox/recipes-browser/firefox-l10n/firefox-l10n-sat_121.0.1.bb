# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf61022f758f7819c9824bde8c2d9124"
SRC_URI[sha256sum] = "b40e6e440aff786ace41cb54878de56cd8c775149d1d5ead885833d9ea25aed4"
