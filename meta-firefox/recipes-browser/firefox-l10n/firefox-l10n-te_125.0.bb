# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12164bbc392318c794c4caeb904bc7f7"
SRC_URI[sha256sum] = "76217c859285d6e8898547e56eb2949de0b5279aed15c01d972b28487ed64bda"
