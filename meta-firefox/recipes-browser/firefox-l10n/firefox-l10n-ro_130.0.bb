# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebe1140120f58dd66fc27670a0d29f5c"
SRC_URI[sha256sum] = "29b653f555520326eb510a502d43076b137eed5eeaec4e2264876e865d572687"
