# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43615ac282431f279e7d576e0635eb21"
SRC_URI[sha256sum] = "3bd032d4a942492a4fc50c48cfecc4a184c45e7ad481be201234d715526460ec"
