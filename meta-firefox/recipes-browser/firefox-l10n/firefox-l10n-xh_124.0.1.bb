# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "078a20f8ddad1714c501a0950b4fc551"
SRC_URI[sha256sum] = "287df52556014002b4a30d1d0ee05e10e7298251634899b2f0ebc4f620f6f260"
