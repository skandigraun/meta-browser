# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6996bd4515f46d83db1566ab54029c27"
SRC_URI[sha256sum] = "fa3cf5f159f3baed1b922ad88427b0df38a98da40624d8d5a51113d4a49c1770"
