# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ec5264db0e80a8b066afd50571076b2"
SRC_URI[sha256sum] = "1685466ea36d292a97439429c9812a4c138279144470d5edd0004d8bea54003a"
