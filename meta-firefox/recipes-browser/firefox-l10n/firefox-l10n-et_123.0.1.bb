# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90fc70e9ec993d454d3923dc6d98d60a"
SRC_URI[sha256sum] = "9912d3dd9df9efa403272f02c8fb8bad4a3f072444e11df5e2a9a180ba3d06dc"
