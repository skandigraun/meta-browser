# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8da07f4bc531ea09a4b950fe4cc4a6ab"
SRC_URI[sha256sum] = "1c25a8d379a9915504daf2f1a0e265591225b36bc553c1809b249585c6443945"
