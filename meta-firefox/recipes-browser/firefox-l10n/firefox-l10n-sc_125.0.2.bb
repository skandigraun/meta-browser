# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61bddd1e610e30d6de5b9269f3fb7f73"
SRC_URI[sha256sum] = "ebd63b55a64e56d60f6d56e737cd3a89c013b699dbd98cdd6ca33b7df2ff4f59"
