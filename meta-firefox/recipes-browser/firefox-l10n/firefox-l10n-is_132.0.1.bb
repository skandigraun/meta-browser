# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a46c5051ac31345c275d0061bfadc1e7"
SRC_URI[sha256sum] = "743df0a96d844f0454de0397d9725e21f96fc3e7301cde2c8717e3d88af790f9"
