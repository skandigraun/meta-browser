# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7f76d4629ca366fddfef6ab342afeb9"
SRC_URI[sha256sum] = "a68a2cf3c5fdacd578b4bb39867e21667c067a26e60b4a125b387d035c18657f"
