# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddad3957e61bf2a61f56e33cc0d205da"
SRC_URI[sha256sum] = "8633b50112e3e28afaf563136b39ff4c6ae745c1b5a91bc3e23504dbccf05f78"
