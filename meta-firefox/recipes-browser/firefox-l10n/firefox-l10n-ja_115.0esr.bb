# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3816080c09efd3fd93d0cdf430923716"
SRC_URI[sha256sum] = "234bf7dd7359e6baa1d96689c129e02c938bd1b6446d30a71e5831a4e772e47b"
