# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed9f9fcfd6cdf8831f9726952f771ba7"
SRC_URI[sha256sum] = "1c95b0fe087a4b110adda19548c8dfc1ca35f2715df87794162785b8653c1405"
