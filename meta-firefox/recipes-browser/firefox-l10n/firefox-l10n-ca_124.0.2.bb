# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5f86b15ad1a7493cfa47706642da896"
SRC_URI[sha256sum] = "c019bf7259bdddf01569cf36a68e95824cb034802477ba0e8ef1683185d9da81"
