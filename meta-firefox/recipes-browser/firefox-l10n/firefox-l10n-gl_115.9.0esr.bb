# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e3f2b4c7b5bd62bbbd29f0628ebeb44"
SRC_URI[sha256sum] = "e3d6c00beafad4daa2d11bf5f47cc0bd1d1c9242e36703515f672ccf563f5455"
