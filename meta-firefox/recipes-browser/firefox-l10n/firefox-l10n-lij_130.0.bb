# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f17744c306f91f88584f4a7688777741"
SRC_URI[sha256sum] = "128035c6def2b1ac9871604a363ac3ed33e759486b3a7eca6822cceeaea58c66"
