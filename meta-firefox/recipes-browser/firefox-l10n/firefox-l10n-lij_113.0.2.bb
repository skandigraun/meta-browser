# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4a38f5b0902a4e74244681bae351112"
SRC_URI[sha256sum] = "83ce8e37aa4c9c119c3ff7eaba55da9f38bfb5fbdd539f3b6bf16e4b87510321"
