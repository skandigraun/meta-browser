# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28ba95e9b7a55f83bf1fb49ebb593349"
SRC_URI[sha256sum] = "110cc0b6e8dae99c88dea738e9922f7fcc444182edf97ac1dce8c8470c1f3522"
