# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5667ef95e7ae1e98fa4e129369b947db"
SRC_URI[sha256sum] = "6120f7423b5920fbb146c95657f311a55662b4f5e7b91f7344425354eb47776d"
