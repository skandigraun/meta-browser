# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4024fbfb43907a6d5fea86fde9363e1c"
SRC_URI[sha256sum] = "76a4bf1f41101ef087d7a9536ca760928d0dd564054250d0c704927ef4dea096"
