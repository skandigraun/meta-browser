# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd0f4c0a9d4b1b8260426f489b2c0741"
SRC_URI[sha256sum] = "760cfec8f73d41a5289451aebf867465b769a6c4a683d458135071cc89d7b941"
