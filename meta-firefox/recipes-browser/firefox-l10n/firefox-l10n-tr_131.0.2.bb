# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "879d46f7aaf2f4256341726ebfc24795"
SRC_URI[sha256sum] = "962e107d202b7d141b157ba2b9288c71cd6cf7a86a3ce68e2a5938860fd886d6"
