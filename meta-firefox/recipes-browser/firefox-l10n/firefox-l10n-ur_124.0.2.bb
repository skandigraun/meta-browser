# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef6568ad25edb639ae88631cfc260f57"
SRC_URI[sha256sum] = "f1c78fd1aa7d37db43257492473312fe1f06e7ad5aaf2f6468fd14c96146e0ee"
