# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d19ed8c2d80f1637c2c1ab7970aa18f"
SRC_URI[sha256sum] = "ba1d4a3137dd16e1c5eaa9a9e3c867b2c2e69bb7b6648ac06486ac31fd7a5781"
