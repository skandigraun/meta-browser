# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f856c67b047631b0c39d9cfeb52b13"
SRC_URI[sha256sum] = "9ccb16502af9109e503bbb8b8dfe38ca18a80b0d38914881c247dd7cad4412c5"
