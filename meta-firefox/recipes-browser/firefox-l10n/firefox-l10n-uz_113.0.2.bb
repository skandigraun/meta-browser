# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "beffce24aeeab5b4c2aefab5885d911d"
SRC_URI[sha256sum] = "c5e6bf20e729a3f21755a9de664d156046198609d2686cc0ed2eda0439e7684e"
