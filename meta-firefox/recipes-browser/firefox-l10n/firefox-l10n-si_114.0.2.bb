# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84075b25571b848f779a570f64da7b9f"
SRC_URI[sha256sum] = "09cc7505e3684b6cbac0ca817e447fd60f9718026fa81885672b46cc2aad0b2f"
