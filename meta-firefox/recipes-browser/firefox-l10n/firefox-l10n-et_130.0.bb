# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25dd239cbb9043cc095e78da12ba6146"
SRC_URI[sha256sum] = "0c0d3c76d1a0a4fa5f3dd309efb1e9790b3fc2b4047f2d5809a5caed3c9a8bc6"
