# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fd77884f3f58beb2cdf6d59549682f7"
SRC_URI[sha256sum] = "b6de7f7cf70dccf716a38cb64d940e6ab280f011caa1883aee59e58a01708fcc"
