# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b0b0e0e7a7ee60e8ad2bcee6336a13e"
SRC_URI[sha256sum] = "8f53de93c57027ef7f37f2c899409776b294b491a00394b26b213e9b36c7a6f8"
