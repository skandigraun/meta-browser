# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dfcd630f44b4de5536945a0e3545898"
SRC_URI[sha256sum] = "541ce5eaff204ccf0959c281d3b6cf48d5359a153b4866b0243ed6b7f4b786ea"
