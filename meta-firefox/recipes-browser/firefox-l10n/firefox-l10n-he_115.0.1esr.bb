# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05c27533be0faef2f5250e20968a0e10"
SRC_URI[sha256sum] = "610668b418b64c17e33f6ee968be49e45be4743fca0d937a03120a800ddf6da6"
