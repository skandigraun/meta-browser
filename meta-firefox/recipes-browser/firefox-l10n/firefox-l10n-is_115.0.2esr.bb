# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06d9c325dd0946b968c80627605efaf0"
SRC_URI[sha256sum] = "f6501e09c21eaf51e077c0c694a23b1d2780340d87323037bb3ed8b8e17f1916"
