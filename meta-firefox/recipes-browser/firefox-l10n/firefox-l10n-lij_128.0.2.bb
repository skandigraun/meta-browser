# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc8a087d350b466ec886b1a052533b54"
SRC_URI[sha256sum] = "515f10dece470efb0e1cc3306280aa953b836b78556b2c77c22efcaab68d2048"
