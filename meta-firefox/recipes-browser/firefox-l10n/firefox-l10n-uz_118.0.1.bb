# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66f029a7eb15a773ebd8afbce09b1728"
SRC_URI[sha256sum] = "c2d6c076308fb6ce1ad1a3fa2bd0a2199a61839264f1fffab250cea653b51267"
