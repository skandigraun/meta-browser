# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "627ac7b903823cbd11d6933d6157950a"
SRC_URI[sha256sum] = "4275e67cf1cecd95ae768f5213e43c57f4cd6d570369cae0d14c09550cd00ac4"
