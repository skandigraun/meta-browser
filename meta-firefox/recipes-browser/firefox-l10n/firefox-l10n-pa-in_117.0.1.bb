# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0acf64602caa00259efdbbb99e0a2864"
SRC_URI[sha256sum] = "ad94be0e6a94d34e012e351d8f5c5345df40895853238a04e0f6eadc72015868"
