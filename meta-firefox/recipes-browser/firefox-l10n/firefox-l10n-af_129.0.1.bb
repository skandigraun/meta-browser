# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67af842d9c3360c90e4b76c9fbb58275"
SRC_URI[sha256sum] = "8d941f5c7768fe08f5ae6d54149c68e15d25de9c8ddac4f8068323f19f3ffdc3"
