# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e527df83e263ed8de554098c388f526e"
SRC_URI[sha256sum] = "44f5773b3f17f2b2e88bbebcc572a100d2a9f86d434b5813808f869b82e2ec71"
