# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10cfd4194207452aacd51c2d7e6e0cf5"
SRC_URI[sha256sum] = "fa56e5c68ca8dd3fb82ec1fb5b9533e59ce3925b36f4369df89e10519726a9b1"
