# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c43e43271141f724a576d3d0a84c68be"
SRC_URI[sha256sum] = "f85b9184bbf8d9aaecb1f3db7beefe22db6b64f86c1965d93a0189c81aaf5e9e"
