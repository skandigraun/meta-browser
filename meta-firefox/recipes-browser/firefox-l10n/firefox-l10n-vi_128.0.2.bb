# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7ccff4e0145955d169604e4aa7faf2c"
SRC_URI[sha256sum] = "59890aacde23e5a2c1509ce89c724d5b897935c173948049068fb8f7b663a7bd"
