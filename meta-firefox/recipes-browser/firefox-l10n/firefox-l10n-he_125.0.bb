# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e64a4f8eb16c00db38eb9709fe742437"
SRC_URI[sha256sum] = "49c03484fcea495d57b77eb6a5d01bd2702241d8175cf5ba9edb137aaed7fc2e"
