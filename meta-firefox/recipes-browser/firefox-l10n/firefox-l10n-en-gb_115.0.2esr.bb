# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7736387a5c86cdb59176da4dd4d5e34a"
SRC_URI[sha256sum] = "ca6d9b18a2ae69a2e5a5b8eadd488781e0fae5dad6b89271be2d98c7926d4e26"
