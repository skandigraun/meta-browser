# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1c2c06a4d14c18e8083b7c2ca2e5046"
SRC_URI[sha256sum] = "dd410d8a6926ce790fe6ac09cd6508c87d83bbc1516f7b05cf3eeda8f0a82b75"
