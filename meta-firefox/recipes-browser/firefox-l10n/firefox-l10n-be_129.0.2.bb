# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1ffbfe97b5cc47b24846de2b2519bf3"
SRC_URI[sha256sum] = "4d07c02490d0152ba33eef86677e8bd64d400284d6d66da510b4b3c2bcdb0c2d"
