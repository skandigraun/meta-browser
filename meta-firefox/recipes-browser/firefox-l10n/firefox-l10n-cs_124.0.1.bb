# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2827af2921985ed246b1685292a7ceff"
SRC_URI[sha256sum] = "8febe3210e60813fd2c4d901e75c16f112979e501d7f9babadd42bc85fe043c5"
