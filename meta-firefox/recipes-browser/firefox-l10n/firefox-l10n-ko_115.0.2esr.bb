# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c23dbb4f456309d1a4cd2470ddabe0bd"
SRC_URI[sha256sum] = "8d70f8b7a219280998bf6abbbe7e4890de1b77831ddf6e586cbfc2a5959d6fd3"
