# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6b393f8b6ac9237abca1afde6550d2b"
SRC_URI[sha256sum] = "bca66900a6070a66848bc0744d5143f289a48e74285d2915fed963ad6f613657"
