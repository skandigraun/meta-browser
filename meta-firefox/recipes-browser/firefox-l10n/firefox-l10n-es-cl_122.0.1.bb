# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92dbb303acf9f37ad8f3ff69040f5ef4"
SRC_URI[sha256sum] = "5a5ab0ecbc3bc2a0e43d8f0c9ab3e4396b1886b19064cfd08667ff45d296e9e9"
