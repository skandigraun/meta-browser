# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "972473d7dc013a1dfa226ce8ec23945e"
SRC_URI[sha256sum] = "7c12fe8475ce20277eb2783a130e3665aa2cd873a42b204409cc9137a18bb7e8"
