# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52cb8305ad21c94b5c168c8c442cecdf"
SRC_URI[sha256sum] = "e7e8fcaa4c7d6394582591241dbc16afe75e894b6f8d6aad573c742df19785cd"
