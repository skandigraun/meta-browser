# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03b0036a4bdca1b612d22be7e5d51c43"
SRC_URI[sha256sum] = "0f1b53639474b0cfa502341897bb5586977537176e5eb8524c3961a397de0054"
