# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d525271e70ec028ed0ec58134dda3336"
SRC_URI[sha256sum] = "076c060d56a3e9bde9d4420dd042210b3aacb1e93a78558a0d6b51355f2e6bf4"
