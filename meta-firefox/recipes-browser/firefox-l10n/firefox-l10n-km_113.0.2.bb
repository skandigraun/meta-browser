# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dacc5b7be277a04c9e53b406fce0b0b"
SRC_URI[sha256sum] = "4d29db1ce5436e5c8120753e834d567aca74fcd4d880af27ec46ac3e5477c339"
