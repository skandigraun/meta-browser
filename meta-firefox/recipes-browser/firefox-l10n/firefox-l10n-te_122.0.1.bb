# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c79ce864936c62b896834b1c5341f6c"
SRC_URI[sha256sum] = "8ea9497973664cb65690f6a619a0753a659ed9cca11ed537a821c4e41b998b75"
