# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae69c55cbbfa6883b101e8eeab41034b"
SRC_URI[sha256sum] = "ef08d6ee60f271da95c28259c19b22c52a502f8a4156c65f8c1d80633b1bf3ea"
