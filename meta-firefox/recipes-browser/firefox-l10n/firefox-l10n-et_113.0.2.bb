# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33e1806e19f8f8956c5ba0dbc9991cbd"
SRC_URI[sha256sum] = "c3b2540962fc73899509b24da4182e7fddebc9735e867e06a3d9d28169e9f823"
