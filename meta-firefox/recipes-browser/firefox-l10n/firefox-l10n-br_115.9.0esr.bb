# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "106263a8f5d98a5174daa43229ef86ec"
SRC_URI[sha256sum] = "b7d3360ff4e547b4ea316630329e9a8bcd755157aa1ded890bcbe4394e8be1c3"
