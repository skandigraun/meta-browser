# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6179fac194264281e59626f27126d8b1"
SRC_URI[sha256sum] = "11246d428b04ea51bf96321964cca420ca5a84cf2cd434ecd243f81156f3504c"
