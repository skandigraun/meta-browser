# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d5051405f4777ba2a18ad3b345ccd7f"
SRC_URI[sha256sum] = "290c8fdad9cd152372a8326629b56ac9aa3179f2c86f7404aea6c0d3a6bb016f"
