# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39b7b5c5b349e93641c093cfff0e3e0a"
SRC_URI[sha256sum] = "b2afd59d16fc334c6b56ceb5f66b2758bd4ef8a640ad5b35f1de6704bcb3875d"
