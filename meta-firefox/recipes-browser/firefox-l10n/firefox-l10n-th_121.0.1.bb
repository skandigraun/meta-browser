# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b66b6b3b922f825e62f1e7a2b87bbdee"
SRC_URI[sha256sum] = "c5d99474eb34befde22e80384f070bef7980bf9b4b72246b6b98ffb7dd1f08b4"
