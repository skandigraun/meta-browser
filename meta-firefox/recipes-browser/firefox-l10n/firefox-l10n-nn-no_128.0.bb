# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52e305a54d5ac2697638744cbd53b217"
SRC_URI[sha256sum] = "4988f17b01428b6957697ef4cbd43950dbcb57950b483afdf6afd21757ae5fbf"
