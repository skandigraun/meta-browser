# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "272570010c5f7f25ae23285b3b48ece0"
SRC_URI[sha256sum] = "d927f6756cf2699193b43746170e5d32b68fe901bd7926e06d6c798527665d99"
