# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbfb2c2e8848bbfc344844eaf0989d5e"
SRC_URI[sha256sum] = "ac5352956096a0eb869759cbbc0e04acc95a3be677b5ef56f2b237ae74567632"
