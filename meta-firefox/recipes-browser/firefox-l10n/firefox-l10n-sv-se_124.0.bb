# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52ef399a9b14e79891a30e80b27dc101"
SRC_URI[sha256sum] = "861da448b989b612e76f2a831c4565df1084ad2225b55767095e60a2d193ae36"
