# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35388a66debd8afadbb39e60cd5a473b"
SRC_URI[sha256sum] = "d83f555aa827993960f34d4da2978b32b0065b924e060f65da7a79977e352517"
