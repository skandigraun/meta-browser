# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f90d9d5b7fd9063206c8abd89b1c732"
SRC_URI[sha256sum] = "e8f7547a68757c4438f071348a51422cf714c99c531b7d54d602edf70d30876c"
