# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6669c30a129893a746e6ab9a72b4b3f8"
SRC_URI[sha256sum] = "77779cfe9aa75f448e76560b32382f1cf2ff41036ba648de55fedd351768a8a8"
