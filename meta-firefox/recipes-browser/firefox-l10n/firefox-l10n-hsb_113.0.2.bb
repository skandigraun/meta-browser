# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "622e4a9ee1e9813638b47a55a8aa02ef"
SRC_URI[sha256sum] = "cc5d3f7ee27df6905e146f5d887b1fa4933187a50b66f007de94fdcdad8978f2"
