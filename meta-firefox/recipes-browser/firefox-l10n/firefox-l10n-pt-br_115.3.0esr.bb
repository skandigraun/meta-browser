# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058dbedf411bff52f4c73f9ba7842974"
SRC_URI[sha256sum] = "8b66282db3067d1d9582648c527611040283b9e265c98f0d58390cf2bd14f522"
