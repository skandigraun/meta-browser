# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "172c4596b7a98531dd2ca8da2256e7ce"
SRC_URI[sha256sum] = "5cb7f8709fdbe34ce0c8b22ba5b6ab61a472fae966d4c53357eabdd17753da51"
