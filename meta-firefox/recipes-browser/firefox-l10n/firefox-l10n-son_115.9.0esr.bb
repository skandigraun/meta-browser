# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77a0a44175b49e16a11695998ea10bfc"
SRC_URI[sha256sum] = "873a6a73024dab752d504e99dfbc11840ed17ba1c5fbc84268860f505e452d88"
