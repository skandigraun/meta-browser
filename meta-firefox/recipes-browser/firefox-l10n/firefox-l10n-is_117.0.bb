# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57390a2fa31cf886c5f7704ff99ee204"
SRC_URI[sha256sum] = "08960b15a6bbb1091b5ad767200f338bb51b65ea0dec94838fde36121ae36665"
