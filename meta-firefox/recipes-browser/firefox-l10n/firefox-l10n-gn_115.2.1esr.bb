# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1ce428ab035ae9bbdadf612e46ac4cb"
SRC_URI[sha256sum] = "461fdf5482c094fc2140b8ac959d259fe17c34226e94b6da1c1abda5c54985fa"
