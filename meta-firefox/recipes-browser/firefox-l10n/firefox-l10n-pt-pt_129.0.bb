# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a56d520b3010ab069d197ab584d7e42f"
SRC_URI[sha256sum] = "db0d56c88e2f644eb744c827fe3b96885e2baa9243214d75853c6947318ba8c6"
