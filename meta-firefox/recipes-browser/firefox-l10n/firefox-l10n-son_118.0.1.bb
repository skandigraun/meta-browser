# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67cee352bed251aab0485767d13ec09b"
SRC_URI[sha256sum] = "b9ef61e58c7d6041b2b94b41c04ba35d506226c0df4b5ad5ce5eba16373adda6"
