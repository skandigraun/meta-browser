# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9caa9f1cde03a8b36d5fc15ec645fb2"
SRC_URI[sha256sum] = "192167c16b81107eae5473418280aa3b882d235a25e4952fea8deb2b9bf1d471"
