# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8af0aff9d360c953f538043f5fd78b4e"
SRC_URI[sha256sum] = "bbee21dc896ee9d3348a9df4b64b523cf70676d9811671ff26d83a97168752e2"
