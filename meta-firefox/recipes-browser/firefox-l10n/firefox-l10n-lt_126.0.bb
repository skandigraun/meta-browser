# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c5c81c511077918c18026dd966fab6b"
SRC_URI[sha256sum] = "2c0acd642bf7af82606618c8039544218a8b27196c48e2f0cd6bddd2d093a3f4"
