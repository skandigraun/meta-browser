# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21c31bffc2d1c47258149f40d3e4f3d7"
SRC_URI[sha256sum] = "e13168975ebbac2ba2b807f7cabc1b2dabb9cb5eb293da58db5e413b45a3210b"
