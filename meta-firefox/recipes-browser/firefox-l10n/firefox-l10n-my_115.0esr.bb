# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d99ee96c66c350ec170afcc5e05f13ac"
SRC_URI[sha256sum] = "948d7233878a9d3fbcf23a5c5ae83500374f609eaa23f8f16aba625d24f718bf"
