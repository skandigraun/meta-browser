# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9172dfb3fccbc64b301214483f679da5"
SRC_URI[sha256sum] = "146e50b47b47cfecd2680b2d323bd9bbfcdd77fb2f701c9b9355d5d932b0f83f"
