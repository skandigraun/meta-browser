# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7867ccebd1d4ffaaccfe6614bf6c18d8"
SRC_URI[sha256sum] = "e757cc1169402dc3dcbeba7966c2b10eb14468c3df2040bcf5e08f44748337ea"
