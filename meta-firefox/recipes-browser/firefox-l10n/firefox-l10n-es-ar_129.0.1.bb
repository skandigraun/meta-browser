# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c0d6ac9f7aa77bd6902b1de11efa3ee"
SRC_URI[sha256sum] = "1c722ea87daa48f77afa32d6847c9c45d3d2d95bd18d6908e91e4d8af35eb6ae"
