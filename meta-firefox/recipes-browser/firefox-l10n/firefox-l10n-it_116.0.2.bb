# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2f29d9f42982cdc741c673b18387c18"
SRC_URI[sha256sum] = "206a41d8d05380251b5a164f30e08095d551dfbe5ee5a885e71d7c13f379138b"
