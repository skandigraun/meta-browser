# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b50449dc4dfbea384638e5bb495f5629"
SRC_URI[sha256sum] = "e761a5c429a5416b7f911aa5dc9e2f735b4d017e2b1f8b2583607c8926b232df"
