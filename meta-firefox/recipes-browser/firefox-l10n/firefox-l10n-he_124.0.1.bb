# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9abc715c0ee35c3205d1459b0cdb499"
SRC_URI[sha256sum] = "a360a5fba2097ca2dd1c503ccbb3616ec28b26e9066fefc306902b68d7963be8"
