# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de6ac7fdc2ced45402f57ba22e82a0dc"
SRC_URI[sha256sum] = "0a8a3eeeb5c079e02f3ab927834eb85b4d6112e98ae269af70a9151b9e60c212"
