# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e01df4610181cf4f04ba141cff52420"
SRC_URI[sha256sum] = "b60260aa5abca94f4eb0c73f5d307451567cadb7dea6cd3b66b3fab930ce7985"
