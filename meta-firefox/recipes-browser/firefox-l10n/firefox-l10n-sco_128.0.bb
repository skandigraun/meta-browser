# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "895a07a401f4a1807e5d4b1dc4418691"
SRC_URI[sha256sum] = "a57e318958a0ea86fbf4fc0b6bf5a0c394bf51ea26a45f112ec1c8ec899d0b2e"
