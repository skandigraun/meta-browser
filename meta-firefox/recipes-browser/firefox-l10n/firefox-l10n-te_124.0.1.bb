# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8793fd6c0b5fea8e3cc980050e0ef00"
SRC_URI[sha256sum] = "dbff0ddb3fbd75c9fbb0378530dd5e951f15b9e7d018a41a2b75ce623bfd160f"
