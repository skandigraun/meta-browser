# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5242f194ff454879531b1536f43d5024"
SRC_URI[sha256sum] = "3e7ed04a128249d58e862481385f20395f1b63a93942a952891f671c92b8a0f9"
