# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "183acf7f5f34e993b4d16be27f540d3c"
SRC_URI[sha256sum] = "4cfc45291de1c0a65f2aedaa764f3ee8ceca734cced03b7f69645f116f733c4e"
