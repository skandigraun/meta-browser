# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e71bd86157566c1165c44933130e1b3"
SRC_URI[sha256sum] = "92ae4780acf9ece5fbe9c0f901416697f574c760e1024f9d3ce043261ddbe055"
