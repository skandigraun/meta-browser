# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "305563180071a535c1ce2a4bc3506a5f"
SRC_URI[sha256sum] = "b4123378a5794b46ba5cd0dd5be361e26fade3abe794ea2a1a1662242dcf8cfe"
