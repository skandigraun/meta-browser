# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba3971469f362be41debd543ae96c893"
SRC_URI[sha256sum] = "3efff75fc1a397aad8844f58c0cb083307101ad31550969ee48fb8e2d3a7a0cf"
