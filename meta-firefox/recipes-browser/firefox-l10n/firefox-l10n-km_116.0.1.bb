# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b0da329a6821c2144381f8313392b6f"
SRC_URI[sha256sum] = "4cf396359c738ab67960be8bb5c9e0fb5aa15500761d788ba015538b8dc3bee0"
