# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15c42c49092f2ffbb0f336bddcab3e08"
SRC_URI[sha256sum] = "717d4a3e3f04b46134f6568eae4c8aa726121ce92c2215e237e1f41880337aeb"
