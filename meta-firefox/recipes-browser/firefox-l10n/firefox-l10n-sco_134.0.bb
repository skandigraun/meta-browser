# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c35a694ff7fe53f2ec85181e407b2bfc"
SRC_URI[sha256sum] = "6f08238bbf30a39fb5af51a2dfe848cf1c6fed1acae97a289ded8bd1015364c8"
