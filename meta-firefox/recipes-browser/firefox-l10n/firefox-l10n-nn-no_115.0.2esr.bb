# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57e799f8411f910cb7965fee18bfda7f"
SRC_URI[sha256sum] = "2fa642eac07561b75228ca7bb2723f94a1f8a39d4c38fe9b876813d114c4485a"
