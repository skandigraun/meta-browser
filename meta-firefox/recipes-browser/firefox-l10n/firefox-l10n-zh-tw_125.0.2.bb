# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7a6bd476084aaf6ba110374f89d88fa"
SRC_URI[sha256sum] = "ea05eb559b1e41c2b653f7016b0f4f0caa964747f030ea22c075e09d50d929f1"
