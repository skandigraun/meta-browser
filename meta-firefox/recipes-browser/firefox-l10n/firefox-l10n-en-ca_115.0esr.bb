# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb4ef7cd1eef5de6f2673d78af5b960e"
SRC_URI[sha256sum] = "513f96ccbf2d8d3e890fa2a5267094b4cbbecf137c3ffa4588a9829e0690d703"
