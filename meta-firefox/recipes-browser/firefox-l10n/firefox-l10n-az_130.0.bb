# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2311f15130f185a74df347785b55da17"
SRC_URI[sha256sum] = "c787ecb59953c6f48f81c270dbf13173040d8e6043c8ce32820f384644dee4b3"
