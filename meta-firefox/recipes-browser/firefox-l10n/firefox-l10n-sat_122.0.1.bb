# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d77f182a43ee7fd23d07d054c476784"
SRC_URI[sha256sum] = "a88235127fd00aeaf6c0848ab59ce5f9aca6c380c0ab6bd405082065e0e09088"
