# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7c4e81cf85aac9109667811f960eb6e"
SRC_URI[sha256sum] = "d497cd57d953211ebe30889246853f19635334274bc733924124321586a010cd"
