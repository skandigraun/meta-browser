# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cedb5e9e89b291ff91e0b7f208a84ed4"
SRC_URI[sha256sum] = "e14d9e686d00b7a957a1132070083c04d7933e942627a47b95c810b7db2a9cab"
