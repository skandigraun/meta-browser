# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b023c03122d49a26e6f8b21bd2a123d5"
SRC_URI[sha256sum] = "d472e782dbe3a4daa2979bba971910a6fb32048f86f558ab5cbf5d12169219d4"
