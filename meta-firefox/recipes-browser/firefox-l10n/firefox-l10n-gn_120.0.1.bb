# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02c80d46b88dc93bfbc3d3dbbfc47479"
SRC_URI[sha256sum] = "de1ff6a18a73c406f92fa07de6cdefd86fd4405f684def43b388e998f6ac25b5"
