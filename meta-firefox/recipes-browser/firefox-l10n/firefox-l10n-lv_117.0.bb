# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bca55cf360a8375533748d8003e9bd9"
SRC_URI[sha256sum] = "1ec33bf739c6b70e40282bb71cad39e7797a44b9939e1c5438418901b9b2aeb1"
