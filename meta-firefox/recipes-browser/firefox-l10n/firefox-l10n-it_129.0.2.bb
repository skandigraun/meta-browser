# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2eae0aaf8baba6e5bc1df4471bdbd4f6"
SRC_URI[sha256sum] = "63e33076bf26e499e6c3ce2c27432db1177f4a14b361ed7e63f59f7ac07b4a94"
