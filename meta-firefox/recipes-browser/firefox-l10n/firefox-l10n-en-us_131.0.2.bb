# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12ad096da65b62027c119b6b161c2cb7"
SRC_URI[sha256sum] = "79a8a9a2640643bcf70e0f8f6c169e1ec676f0695a30348862dab27fe12c7878"
