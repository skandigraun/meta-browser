# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a7710fd0f52cf95f39dc0dc6a068c68"
SRC_URI[sha256sum] = "2aeabd0dc632cc012964e1109fc3306655241362b2c67826f904d379a5b5c31e"
