# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce1b9e04f632db3e16645f79e5e3e0ac"
SRC_URI[sha256sum] = "ec6589167bee670811ffc7e7f7dc2c4ca58a0d6f8677f0bf3b1e743c6086bc76"
