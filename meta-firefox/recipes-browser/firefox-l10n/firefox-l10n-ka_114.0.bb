# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed0e9788f9f49367212c10427a7b0b7b"
SRC_URI[sha256sum] = "cab3fdae9481f6b8d4f81b91377771022de050a5da63d970b0b35c9a4c8c82f1"
