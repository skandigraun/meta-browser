# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e60b15cd24c51f9469b26ed8011d5ed6"
SRC_URI[sha256sum] = "3795e3d6fc43f4eaa7defa7d73d428f67345278cadd63f7bef8d720d552db956"
