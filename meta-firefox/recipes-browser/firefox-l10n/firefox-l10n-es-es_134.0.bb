# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "700930d84f20a2b4e4f2383792bb1d15"
SRC_URI[sha256sum] = "8a103d2d7537bbb0f8bdcb7f17bd0a662bac3ca1232361e6c64e44e9117132d0"
