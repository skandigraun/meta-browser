# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2504ccfe6d24b280494517fb8487d764"
SRC_URI[sha256sum] = "412e2a796108ad35d95f550124287a1baadba4641e41986ffedc76720267fb83"
