# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26e5cde55ea5b04a950cfe6aa0808967"
SRC_URI[sha256sum] = "3b0261830b15de74d6c73af12c983981571ca39dbc97b5f4dcea06f28e527e70"
