# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc87bbc7cfcc95c1c077749bae1272f2"
SRC_URI[sha256sum] = "a16321a54b93cfd0d1021a60c7f251ec2a7c22957fad9a15714ca47c84213361"
