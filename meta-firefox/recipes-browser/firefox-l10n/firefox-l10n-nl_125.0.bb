# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "496393d08a880c659a179fcd0c55804f"
SRC_URI[sha256sum] = "9ea3ff1d3267b2c850fd57e32c40685f4bb580d13608607a86df78d483c70d55"
