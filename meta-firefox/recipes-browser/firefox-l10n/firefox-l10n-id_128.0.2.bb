# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "724426e93fe8c637096bc64f8323f8e8"
SRC_URI[sha256sum] = "42955b822a8031f82d8081e9c5cce1ab5298e29a66cac40871511d8662319b97"
