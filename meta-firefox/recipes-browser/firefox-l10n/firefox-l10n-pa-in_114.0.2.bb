# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "764ba9f98c91f3178d99faa850ca7ba0"
SRC_URI[sha256sum] = "49fd427af7e6e2794383d85b74945eac9b550bad87bc746dbcb37874c638b815"
