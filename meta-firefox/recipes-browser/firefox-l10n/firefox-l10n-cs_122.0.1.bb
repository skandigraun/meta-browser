# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e4e0467fc85212d2682636b63a9deba"
SRC_URI[sha256sum] = "e38972aa6abc052196d6a65f6e6ff54a3f8ecfc0cce9fad140b359ed7c5a7363"
