# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0d7364ce5b399709fad250ec9a8c1ff"
SRC_URI[sha256sum] = "b931c349ad875306120d7115aa67cde88aa8614981fece0b4d0ac022f69f3576"
