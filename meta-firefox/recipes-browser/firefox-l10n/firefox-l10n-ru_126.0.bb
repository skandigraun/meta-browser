# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84592ecb74568e4f158fe728ce22d2fa"
SRC_URI[sha256sum] = "ec8393b538bead280d799a9d4ab9dd4c1cb49bf053db95ad9883cb2a1794f0ec"
