# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "342206a1ebe36d4da477cd655e67ac07"
SRC_URI[sha256sum] = "7337e67a373aae3c5c37c127aee21ba589747a7ab5030ef3b4b2818e8c0a8645"
