# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b1a89acb317047a4e5957be9a453140"
SRC_URI[sha256sum] = "3db6b481117ead59a84b46fd726eeb84a5074a3601e8f30647cf7c4843b41313"
