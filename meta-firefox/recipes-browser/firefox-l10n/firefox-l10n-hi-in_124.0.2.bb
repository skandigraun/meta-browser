# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f90b66196ee23d03a9c2f5ed4b8ba693"
SRC_URI[sha256sum] = "7ce81d85806b87377986879057e9f23a4efc8ca22771d8e84f9789093a3b297f"
