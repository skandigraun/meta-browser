# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3f925f48a635121f93af1a3cb579925"
SRC_URI[sha256sum] = "e3ea78ad0559ca6e6780a2fa9a78f868b374c3e7d21b9c20156da6a9236a20ef"
