# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa6a764245eb8af83365d0aed3d13b16"
SRC_URI[sha256sum] = "1e94c2fc971eeb5dab6ddc656ba1336757ba4eee167e6618fa4f0de687ae7fef"
