# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03ca9cb69f007aa634012e66ca176247"
SRC_URI[sha256sum] = "baa1e39602b6235161979240eb72a0ffacb60117056b4dd66cf163666890eb99"
