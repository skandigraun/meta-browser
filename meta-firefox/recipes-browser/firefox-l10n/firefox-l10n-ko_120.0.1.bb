# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab74cf9b09c967ba8f17274442381065"
SRC_URI[sha256sum] = "bcae9395037cebc4111dbbbc3b7fdcfe41e99ed4ce6bae258b05cfbc82717e50"
