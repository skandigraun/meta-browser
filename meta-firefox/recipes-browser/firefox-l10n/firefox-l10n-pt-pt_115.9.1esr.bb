# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86622f77b8896261bce500386dfda5b8"
SRC_URI[sha256sum] = "aa3ad79eccb11997b9c800e9e5bf29ebeb7265a95cc56cacadb63601a9515b06"
