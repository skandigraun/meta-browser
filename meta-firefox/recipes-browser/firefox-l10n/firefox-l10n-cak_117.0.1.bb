# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "449336579b96846b179c4822807cedfb"
SRC_URI[sha256sum] = "c8e77d54e0367da91c8d84aadad308049c7a7ede630241666ef2427cb1031d79"
