# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cd41651c00a2d1bb84d3f8a3d2d6a10"
SRC_URI[sha256sum] = "acb79690413b25be64aed47149d4a81482107a1cc4bcf593bdfe3ba392219e7c"
