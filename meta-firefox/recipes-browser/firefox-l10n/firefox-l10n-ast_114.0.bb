# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "808b54e517adb63442199a91ea8809e1"
SRC_URI[sha256sum] = "34423da9b8cf41b280a3c6dc998da72004bc2ea0245dcb59af6cbe26a6683b68"
