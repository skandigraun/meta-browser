# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24ffa9d3d0d2dcb66356b0cad633909f"
SRC_URI[sha256sum] = "4295957c2cf0c46d8ee083749d5724e44252961e5f62dc5a91f1ebca38ab7fcb"
