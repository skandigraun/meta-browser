# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd4f0e20974d5ee333b2e91132000674"
SRC_URI[sha256sum] = "db4822a05a9097dd3bed1cb5f5af0c532a0f4e315d39784be47997a5e2669307"
