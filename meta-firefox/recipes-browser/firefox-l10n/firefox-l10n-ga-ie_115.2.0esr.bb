# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f292a2ff4085202d5fdd0fe2d4218d57"
SRC_URI[sha256sum] = "65cc507016def1975cd57291a8a983fee22a12f41e48344a2cb88683fba7cdd7"
