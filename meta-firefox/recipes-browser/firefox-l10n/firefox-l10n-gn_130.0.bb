# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ae1dbe4f1910ac08a46255137ac0128"
SRC_URI[sha256sum] = "c587bed0d02eccd0bcf22128c947b6add910f2e4f1e484dde577569739ce1ce6"
