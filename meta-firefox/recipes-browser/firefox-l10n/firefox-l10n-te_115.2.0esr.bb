# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f0b391dc39db45edc04f3ba8a477a96"
SRC_URI[sha256sum] = "c33e8404f2423eac84ad412bfce568c853ca0096a748a3439dc91f3cfdc95c0f"
