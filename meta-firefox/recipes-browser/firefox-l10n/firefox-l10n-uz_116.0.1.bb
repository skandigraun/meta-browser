# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c16c2bf99076c06ffb16ed27a37a9f76"
SRC_URI[sha256sum] = "ec203e33e352581af280e750cf82dce07ab3acf10de94e5c5a2f908b4810531e"
