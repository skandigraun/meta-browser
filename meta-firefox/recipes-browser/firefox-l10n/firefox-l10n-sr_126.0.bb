# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e7d667ee1a5db6c42b19b0384241ac9"
SRC_URI[sha256sum] = "d2a5927a092f2d3e9700b5e74c7c88d83c47dff1e02af4f8e98a3e4d22497150"
