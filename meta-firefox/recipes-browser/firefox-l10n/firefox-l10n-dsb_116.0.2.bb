# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36995f2fddbb7dedfb4ced255daf6f36"
SRC_URI[sha256sum] = "0a225427afbd45fc57e66499b85a8119aa79bfbf634126e03ffc40ac564b47ff"
