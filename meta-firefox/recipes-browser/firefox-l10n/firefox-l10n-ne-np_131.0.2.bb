# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bc1484ffb9a9d977c5f1831b5ed9377"
SRC_URI[sha256sum] = "627e61c80bd0837bda096450eb2ddef15257af7dc888b1d331e587c57269631c"
