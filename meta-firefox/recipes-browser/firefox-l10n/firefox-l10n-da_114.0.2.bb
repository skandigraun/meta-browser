# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac514953d0faa479edc821456d45ae94"
SRC_URI[sha256sum] = "493f0d9554e10d193f317f471b267e38c995508656b056d6bbc6a8c7921ef503"
