# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6e8232ba4f06315f6101431ad5ee4a7"
SRC_URI[sha256sum] = "c978db2748ded7cb5538fbd8c053acb509ccb5ab0a77ee06fc4b7cb6307e7354"
