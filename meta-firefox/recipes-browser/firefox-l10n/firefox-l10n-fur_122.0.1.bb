# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12eb65a3b097475fa07ff79ffda5faa8"
SRC_URI[sha256sum] = "b71dd643107167eb076efbd5bd2d3405786393444df165a21fde2aadd67eb301"
