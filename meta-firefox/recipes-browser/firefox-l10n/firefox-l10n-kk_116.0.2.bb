# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "475656a7f756e0c1f0e1d7be80ab00ac"
SRC_URI[sha256sum] = "a41361b4182e5fd1810832b71d1227e2d347088f5a3e3750ce4c7f151ce60d48"
