# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bf0bca25abbc795bc7716bd2c3a14ed"
SRC_URI[sha256sum] = "4954d514c95f05e3d6e7d89eee7ae00e9ab44ce61a1f62c9eb530189dfb66d71"
