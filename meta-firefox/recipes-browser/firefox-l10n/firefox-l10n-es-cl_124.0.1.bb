# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7f4efc59f3ed2c46e4a955779bb4658"
SRC_URI[sha256sum] = "69a3b57ad09018c534c040ce5c6cd2c4025ca74fd36e7a24644362595d5ed6d0"
