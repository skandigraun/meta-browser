# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "729029ac0e5f0360edab528282f9ecfd"
SRC_URI[sha256sum] = "174dd9dab27baaa000496a7b9663551edb62d5777f3ebf6a6e996f46436bbed7"
