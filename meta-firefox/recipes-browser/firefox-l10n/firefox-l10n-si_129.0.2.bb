# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ff0dc536326f57b1df7138b76092969"
SRC_URI[sha256sum] = "fc2d95dd5e74107969ebdcfec77dc9a917c53df376f02decd28d6af49b08f2bd"
