# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff5e2603e93ca4f295a89911e7ae6fd3"
SRC_URI[sha256sum] = "ddd3022cabb7c78b585cc20e9fbd57aa8dd0bae73a9f22aa97290e8f4d295053"
