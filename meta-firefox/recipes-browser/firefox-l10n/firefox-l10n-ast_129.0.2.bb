# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d4eb1d704acef6517397b4d1d792bcf"
SRC_URI[sha256sum] = "d10558a8419c3f12b815f4c1c01ba7a028038c9a44fa99239ca4971f9417847e"
