# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51bb2b1cae1c12b7833e03d1aff6bce1"
SRC_URI[sha256sum] = "183a7e6490cc4a58e9b5ce6eced6773a993729f68f9ff1f8d4fea4dd8feb0809"
