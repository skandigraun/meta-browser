# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dd6ce772c6b28d8ae1ccecadd48b10b"
SRC_URI[sha256sum] = "2db0fbd22be68740dcb648e7785f6c52e84f339a40fd9001379b6256510ec2a1"
