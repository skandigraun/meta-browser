# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deeef7701277d8749672ce891af0726d"
SRC_URI[sha256sum] = "d74da2257e632535bcd8d3989918b0004c28f89dec2c4315fc353cc008ae58b0"
