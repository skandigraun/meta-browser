# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e57c55ea9f305815ccd7e747ff73454"
SRC_URI[sha256sum] = "8283a7529ae0f7b4de25b3944dd710ca23ac90877a13d2c2a9a3e223c9f73de3"
