# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80078c490ce16ead1740ad5d69e4fdd9"
SRC_URI[sha256sum] = "7bb817d470d29cacbeba8922ca7de248e20ab4e6dc707ddcd652bdc919fcee68"
