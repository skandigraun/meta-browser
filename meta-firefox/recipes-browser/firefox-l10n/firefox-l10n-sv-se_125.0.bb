# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d15649e1a674a2f87eb5b2f8fd07d33"
SRC_URI[sha256sum] = "24d9bc087e2ac8c4a77f661928b84a6fc95824c555b9d0b876e47d7011b783db"
