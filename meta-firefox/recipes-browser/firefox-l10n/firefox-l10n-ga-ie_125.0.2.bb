# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73ff73e54d64cd6006ea28e1a6f1908f"
SRC_URI[sha256sum] = "0db167cd0694e41c212b0aebd57285382b6a09c1195800aa0af3c1e73fc9f2d9"
