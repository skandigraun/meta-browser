# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0704842443aa86c384245c26f5222906"
SRC_URI[sha256sum] = "fe2b0d2ace1c3ffc0810be200a76c612c4ef204c6bfcddab308be1ce12bc43e0"
