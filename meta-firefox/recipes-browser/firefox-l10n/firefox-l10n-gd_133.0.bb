# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce87928ccd1acccf74976789270c7019"
SRC_URI[sha256sum] = "d52ed4c6f9011ebc213d06f1b5759b56f26b3832ccc05c5b4c582bcf41ebbcf1"
