# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11e380c30cfbc401456e3a7c96263923"
SRC_URI[sha256sum] = "7d0bb52ac57cea56d4dbdc0695d3740d1af2177788c73c627158b70414f54eea"
