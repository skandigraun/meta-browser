# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab5ad236cf6192c27803faf4f154e38"
SRC_URI[sha256sum] = "66e7ca466b5c552bd5b02e10d1d08ee277f762f9a850e22d894d6095b09d9003"
