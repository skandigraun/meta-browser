# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e0d9688a7af75af5e7aaf73cc827b2c"
SRC_URI[sha256sum] = "dcac3042234987fcced7afce7eb85f8fb8081bdc7bc92eb769e62ae9c5c8784d"
