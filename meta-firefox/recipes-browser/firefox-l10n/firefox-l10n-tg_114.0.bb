# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25d874988f93d8d139d357a05b22f4a4"
SRC_URI[sha256sum] = "f134a8fb015394eab512999e8081d54051c1adbe1e043674f1b07fa41c6d6d6c"
