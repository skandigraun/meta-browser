# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "943a0d6c00b4b013be90e042f8d393cd"
SRC_URI[sha256sum] = "73d6f698b1d410c6d1f68e74035bbdf6935ab13b0d144bea5581985d3bcfacd6"
