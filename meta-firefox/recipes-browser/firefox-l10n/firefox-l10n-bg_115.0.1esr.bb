# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23b8d4cb81dc1e6af95dc03df089a43e"
SRC_URI[sha256sum] = "b1d1004a256c3118d1feedc5b42fc22754e93a391de8eb221c3ca5342e9fa9e2"
