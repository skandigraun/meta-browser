# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b558f0742e5560d775762ceabea48b63"
SRC_URI[sha256sum] = "e625dc375e977e50f400c08196c56fa320bca8ce00b971adcd35cf624f0a979d"
