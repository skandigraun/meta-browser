# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d6f91d4836614d3489d72077beac60d"
SRC_URI[sha256sum] = "689964460463a363eb473ba37cd27246ea5f69f646e384d2e195cb4c791898b9"
