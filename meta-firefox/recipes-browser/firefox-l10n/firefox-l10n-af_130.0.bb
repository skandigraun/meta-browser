# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcc245f4a93d4ac19b4f5da5059c9bf5"
SRC_URI[sha256sum] = "db717c7df34053d2c4e40cd66adbf4413a5af1c407622d85164428075e5e4b76"
