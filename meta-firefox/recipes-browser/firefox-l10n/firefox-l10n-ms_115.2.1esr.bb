# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a03dd946e9e4d65876bcaf046b13ef0b"
SRC_URI[sha256sum] = "14bf9db182c43fb28165ce4915c14377f8fb53d2b0cf5a854141c8f640c003f6"
