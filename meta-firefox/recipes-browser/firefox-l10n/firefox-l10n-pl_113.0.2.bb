# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7006efef25e72d4366c3bd8a1fd9d311"
SRC_URI[sha256sum] = "ea365dba2041d104a1da3d8db0c85082b4f7df1fbce3392a802b51e6cc00fb5c"
