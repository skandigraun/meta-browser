# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ffc001ee07f9f9373bcc2e77a176f1e"
SRC_URI[sha256sum] = "6859970d4e48662c30e2b61ede15f85217a3692eb60256dd036b25d3ffaed661"
