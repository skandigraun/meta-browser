# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de9ab34b1b7d35ae4f1041b36fce8b66"
SRC_URI[sha256sum] = "fc692d715284574edf204c4f44f8bc05633ce4a8545a7b1f2454c5c555ab6dc4"
