# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88e6d20ccb3b05ff41fc123ffc44b4ad"
SRC_URI[sha256sum] = "e425695de81f98737eb9d1291bdbc9ae315cfe39bab2b76d7c1d7bb9d0ac5e6e"
