# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6023ad22d7e55eb8f152438ac18836f"
SRC_URI[sha256sum] = "c33d787698370a8e307ca39ac87290007e2b5bed405d915225167fdf1051ff61"
