# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a141d77dffd6b161fc99f9360055942b"
SRC_URI[sha256sum] = "d59149eb53cbc698cf8d0a7daecf4e278f48e9e136b9e8352feb955f9d726c50"
