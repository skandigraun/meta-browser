# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1f1ee3df5f1e58fcb24bb9f19624be3"
SRC_URI[sha256sum] = "114ae0512d42f9f546f694ba7513b77426d00ebc45cfc839e965bccd43bef56a"
