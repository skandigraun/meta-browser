# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "769b97a1020544eb9ab66aa436010ca1"
SRC_URI[sha256sum] = "f0b77a56215baf8546b06a69e7211319af04e3baeb5c06a0fe0519787d949d8c"
