# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49781dc57b8fad2813df1d8a418784d5"
SRC_URI[sha256sum] = "db9082ec3b0305f0dbc61b74438855212c16ed5c17132e9990c0cd5e987e8fe9"
