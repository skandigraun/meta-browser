# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf083fd0e1059b4bc76da9daa4d0385f"
SRC_URI[sha256sum] = "d44f851000a70b56a2e3227a6c2032464c54d8a0201944b3c1ab73b00215a91b"
