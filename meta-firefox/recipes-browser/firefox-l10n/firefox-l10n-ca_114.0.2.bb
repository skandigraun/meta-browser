# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a20f5502d8d780fd6dd8b05f1b13e1a9"
SRC_URI[sha256sum] = "686bb2ea49af2445efdee04ac22fd254ca82993d39a28865c6acf814a43f322c"
