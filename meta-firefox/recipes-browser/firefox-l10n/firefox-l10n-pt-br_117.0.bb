# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72cbae58fb48ba4f11f2720c9164d6a0"
SRC_URI[sha256sum] = "d16bcadaed9ef2214129deda0179c7b20839ecd08b0da1a66dc03708d24fd24d"
