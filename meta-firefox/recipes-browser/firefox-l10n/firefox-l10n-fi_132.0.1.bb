# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e83b2214a67674500857df9336b5ccaf"
SRC_URI[sha256sum] = "d274ad0d7191d908811e11e1c9311309a9fef44d4e74a6d0c57ebea1898a8170"
