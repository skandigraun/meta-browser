# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a7428ad6b8d93a4cf7aaa6958d84ef"
SRC_URI[sha256sum] = "69551d988fe1836c3487eb5b0a684a693761b7f0b388bee068b02ae58e634b0f"
