# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25da71a4ed3166df5a94a7d86eef6546"
SRC_URI[sha256sum] = "c749ca1e8564b4f4c6877f48a438368289214284318052f7e0c74c53f5d3d7f6"
