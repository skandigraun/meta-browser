# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3c3268a7ea7cfb03a975dde2d77225a"
SRC_URI[sha256sum] = "7e948339c19e0e852a5022535728f9bc24556a12e3d413abd30497ffd0bddca5"
