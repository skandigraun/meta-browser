# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9a669fd1c7dcd35f8b56596fcb75de3"
SRC_URI[sha256sum] = "1a5a858c9c67d1c7c30c119596fb9e14cbaaf32da844e52c5488c91b96f2874f"
