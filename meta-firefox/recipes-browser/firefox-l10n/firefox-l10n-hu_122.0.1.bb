# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7cb14f05cf04aa0b8fe09dcac9b9301"
SRC_URI[sha256sum] = "8cd8e89ec84b170f52ad9418718ef0d63cadde85d92a74beca10097d8bb12b74"
