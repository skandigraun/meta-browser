# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0448fed4c13c3c129dd4fee43c1184c2"
SRC_URI[sha256sum] = "3055b75ed8e18bd9836ff777e7055913d5800832ab49c1d2a0e1692ff1676dac"
