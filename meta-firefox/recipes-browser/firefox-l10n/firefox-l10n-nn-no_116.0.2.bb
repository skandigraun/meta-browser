# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39e93a0ba6fd87fe03ea5c55f9c5a9ad"
SRC_URI[sha256sum] = "27271e93df1f6f19c6b2b7db1900f66fc9769c7f1931ed5fde9a8ef466927eb6"
