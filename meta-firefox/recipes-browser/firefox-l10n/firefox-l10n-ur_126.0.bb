# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcee28cc99844f2741cb072dcb4bbdf5"
SRC_URI[sha256sum] = "8085dbb9cbbc7f609818155a7028ae3dbd4ed59ee551b46cd51b236ed9b4ef83"
