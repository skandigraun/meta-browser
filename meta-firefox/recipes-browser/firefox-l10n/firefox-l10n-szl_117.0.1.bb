# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c657ddc736dbb82cf4590f99987629"
SRC_URI[sha256sum] = "f0a0031d26ef3e123aa75f10fb0a389bec82d45e92cac3fbfd7bab8a33b3056c"
