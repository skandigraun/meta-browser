# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53725a2d3f37d7f0b2397daaf733064b"
SRC_URI[sha256sum] = "ecb75e9efa329e84df992f7f2c64ebc6d9c46e1ea24f02b8e9d479270b9c526e"
