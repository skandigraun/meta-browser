# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "510529b2e79f85144c86018d0c8b460a"
SRC_URI[sha256sum] = "fa37f1d7ac00aed45f6a08a7ddfc9fffee7084dd013139d1a7a309e07699414d"
