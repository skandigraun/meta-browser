# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3cda3bb5a58a5a1963c72e6456e30b9"
SRC_URI[sha256sum] = "d50b4c16e363648818823167faec7c4e0adae85d5983f15ed7cc23ce5db417c6"
