# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c335f1907e3822bcbc4ba2a50f04e9d2"
SRC_URI[sha256sum] = "ee99c1aa6e09d7481fb2a13db9a71a7f522dc29c5a2651aaef22ef81df90b03f"
