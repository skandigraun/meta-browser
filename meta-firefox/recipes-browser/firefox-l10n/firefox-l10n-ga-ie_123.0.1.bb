# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf1ab0a247953304bae610d7ceb1f93a"
SRC_URI[sha256sum] = "dacc5b5f6d343a08f88c6224d382c2a0f17429c7993faee4bb078a20ddd3be78"
