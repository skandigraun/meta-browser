# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8965f9c2fd0ea59c17638c6a7e0cedad"
SRC_URI[sha256sum] = "f4c66972bc9cf10a4909b3d7114b6eedafc79032efcefdf45a9091f8fe7dc477"
