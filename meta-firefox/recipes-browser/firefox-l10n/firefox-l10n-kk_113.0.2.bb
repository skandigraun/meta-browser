# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0821e201681c86730495ce0e8fe8073"
SRC_URI[sha256sum] = "912135708a5dfaf8507ecb9bc8f4c3e7373d08409dd52326a932dc26d711f23c"
