# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b84a45e4d47ba1c45e4990ee169f201"
SRC_URI[sha256sum] = "d08fdfca0c80fc48be30a66cb72e4460e7ac1178d9359699e06665d9b027f2f2"
