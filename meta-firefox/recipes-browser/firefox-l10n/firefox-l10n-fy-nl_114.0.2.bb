# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a395a4c67e76f57d520748d9a449e5b"
SRC_URI[sha256sum] = "23510dc77ec3f2f3cf1cc73432c6c3c9d1a51ea496205e86fa463f536b8cd6f4"
