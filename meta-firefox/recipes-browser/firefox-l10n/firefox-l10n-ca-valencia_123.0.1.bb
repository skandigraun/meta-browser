# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d17fe636246a127d5c5df5b05abc4bb2"
SRC_URI[sha256sum] = "878e0c93085e99ef02082a17385d280647100f1b3264021a6e48757e3d5cc7fb"
