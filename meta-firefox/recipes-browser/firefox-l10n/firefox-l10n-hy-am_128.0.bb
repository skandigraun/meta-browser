# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffc0f398ee8e76f8afcf1ce6ee116e36"
SRC_URI[sha256sum] = "890cb2e36bf932b605adf22422d55025be53eb8f7e4bc765a7aaf73e71e75a10"
