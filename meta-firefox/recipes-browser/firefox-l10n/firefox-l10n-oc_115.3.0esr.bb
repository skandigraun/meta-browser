# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "210bc11e9377a8567ef7a77e8d20edc0"
SRC_URI[sha256sum] = "b86c123b1e90daffbc047feee643058a9358c7bec66e183f57b6327a2de4e297"
