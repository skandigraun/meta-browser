# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c00b95cf11f3bcb9f99de51ce2925b3"
SRC_URI[sha256sum] = "d472c61b25b28c8b5e7405d093aa123a527e4602ec89d691712cba949ddbed7e"
