# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2c0895d05892453fbed1199e38d2731"
SRC_URI[sha256sum] = "cb0df6a13e0b36d61ebf69f12d7c4324b804dc9b47103bbd259fce0c2be6237e"
