# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c378c1777615f75066a53cc36914788"
SRC_URI[sha256sum] = "7ce45dfab3783966aa5af1088e1f528af0dd808f8426bc070980e4a27c634247"
