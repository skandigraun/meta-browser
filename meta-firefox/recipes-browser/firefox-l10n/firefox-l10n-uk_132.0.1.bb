# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f01d9bf26ea5cc4d68d055589741a377"
SRC_URI[sha256sum] = "e4003fddd6f740c3fa0baa55ca246bb9b7a8d0983ad795eecf572bc7f2752415"
