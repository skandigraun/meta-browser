# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5864201dcfaed536c980cf74d5a30e48"
SRC_URI[sha256sum] = "715c14506b5dedc278e49198ad50e2be526dbd63205f30e7cf1aa182f6e614cc"
