# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2bdb63f07dd80abd4704d007a2abb18"
SRC_URI[sha256sum] = "6e0ea5051c8021722cbc64d3cd4a0b87294d196cd3a8236760e2162d37a25904"
