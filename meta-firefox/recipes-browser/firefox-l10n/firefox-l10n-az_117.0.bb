# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92e5c82330858f8ca732db23d11bbe24"
SRC_URI[sha256sum] = "8b3d89b3236577d7215ade532714700cc9a14b7bef51b86d31d744e625141622"
