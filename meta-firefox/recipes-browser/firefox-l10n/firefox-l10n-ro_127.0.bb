# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00ad023373b855b4837d920d1f48cf5d"
SRC_URI[sha256sum] = "b1f6d71df3a7806d8cd3122de4ffb1fbb3664fa6b80815da7383df467aaa9655"
