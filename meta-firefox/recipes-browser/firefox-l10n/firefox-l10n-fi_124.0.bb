# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06db7263836e5ded0d8394cd9e0590fa"
SRC_URI[sha256sum] = "f49f239945ee2a127c96ce77182929a34d9951638dd7ed1191fd94482311bccf"
