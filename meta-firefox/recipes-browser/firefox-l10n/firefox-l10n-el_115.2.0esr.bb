# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d94574dc9cf69bbaa2a73aa2e0cca967"
SRC_URI[sha256sum] = "89b986b0af3f751b650ed77cd2d1ac5b385f823857f4f1fec30a2a517a462e22"
