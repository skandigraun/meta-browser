# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b57ceb70d7aa8241d63e06d027c75e0"
SRC_URI[sha256sum] = "b0af642088b77687dec819ca964685ab3c7a9c4ea3ffe26ccaeeb398b0a49f1a"
