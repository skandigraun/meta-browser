# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ad3e54e53d3136dcb104ba46d1257e5"
SRC_URI[sha256sum] = "75d723aa352b427f231e600080c643b99c8423c41f8e22702a29f4ad000d7cc2"
