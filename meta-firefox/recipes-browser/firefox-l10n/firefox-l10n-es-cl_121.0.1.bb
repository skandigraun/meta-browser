# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64eec1103d501bac174b41a22d4d0228"
SRC_URI[sha256sum] = "5c557f208db83824e0beeb656dc7b410d26bfd4cea1cc2ccbecb2595225318e8"
