# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32df9d2971704cb4ac4fae0e4878e6e9"
SRC_URI[sha256sum] = "6bade6924cf305ac90aaf8f71ec86a9144e6914c8c116a14f6340e17f9325aaa"
