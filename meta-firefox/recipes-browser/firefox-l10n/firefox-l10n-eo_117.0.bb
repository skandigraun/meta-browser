# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72dcb1f0512969f5650e7b76f676c1a"
SRC_URI[sha256sum] = "f6cbd7bf1a891db6dde76640729b47d08f87ae9a52340c73a82c5a58daa52031"
