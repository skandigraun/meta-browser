# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ea1a3d728b92f05b615e85edb9fe3d"
SRC_URI[sha256sum] = "00b5689b34f9b6ff48d4d7d68f766a281bc501a91fea74f60377579ade1d4abc"
