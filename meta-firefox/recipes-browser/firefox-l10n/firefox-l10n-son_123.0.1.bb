# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a845c379c528b6a876525fa133a8b0f"
SRC_URI[sha256sum] = "faa7314d02724dd9bf9a8c36519c1792450b4e83b2d39b1b79b8277f9bac84a7"
