# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2de36ad6380ca3e4c88c09314ddc3e3c"
SRC_URI[sha256sum] = "2abb4dbd936bb11135e867df95cb9f534c900c67ba822801b9aa65a418c3972c"
