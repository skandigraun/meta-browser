# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "724635b84d2d3e5bd825fe4f656bee9d"
SRC_URI[sha256sum] = "be9ae572487d115d485b8af87143aeb99881dadfa9c253551c5c6e00ee4f4ccc"
