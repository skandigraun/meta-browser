# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a02069f8cb9e5adcccd061f576ac095e"
SRC_URI[sha256sum] = "3c9b56539542ace8a6481400800367a07e980ebaad213caba3e5fe2da15bef9b"
