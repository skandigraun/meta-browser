# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e447b08959a04cf4ee2523d86a361b3"
SRC_URI[sha256sum] = "8daba351fb49e30b4f406811e902cf79ba1606606ca202e84343bf37c876bb2a"
