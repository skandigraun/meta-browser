# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e374275601eedc28b6ee817122ff2724"
SRC_URI[sha256sum] = "4886d23fa6ded9ad4ac860c55a5630118817ec33f28773f443a5041eb0918f6e"
