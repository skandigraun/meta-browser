# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "baec3618ff5d6e5f73a12e021da7b363"
SRC_URI[sha256sum] = "2e1ba76552a7f8afe20ffae33a478fa300a2ff50237c0f9f18236a379970eba4"
