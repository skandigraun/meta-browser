# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2761438863e50c0177b15e623a92e697"
SRC_URI[sha256sum] = "cfad38ea9d7ac2d0e907d90774fd324d4c9ebeb693e07352d1320f6a7528b16e"
