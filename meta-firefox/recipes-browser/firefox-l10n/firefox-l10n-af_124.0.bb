# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f40eacc58dac80e81fbd65c8f9e992c6"
SRC_URI[sha256sum] = "df3f81ad25cbdadeda07a7a341c0f20628245e4adcd6c176b5f85a2c1c9b0947"
