# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "269e2929c29a65fda9d1e9e63ca2439c"
SRC_URI[sha256sum] = "556b72095b843edf7376ec8cf93b8da93b19e08253ae13e75f099c6c4715bdc4"
