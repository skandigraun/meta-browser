# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d479ae5e441ee4d9c7419de8a4e3ee7"
SRC_URI[sha256sum] = "516356d8fca5c7925db9d8ab1b25fc4e748a340e9d35d011ea99a99b163c8f8c"
