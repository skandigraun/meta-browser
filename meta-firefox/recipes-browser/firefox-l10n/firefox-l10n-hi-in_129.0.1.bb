# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ca6383ddf798a57ced7fc7c969f52bc"
SRC_URI[sha256sum] = "ca29bb36884f13a6868b751afc60080db2ea2ae43848ce8c4c4eabafc17af415"
