# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1d88af5af41acc73247d87a979cf360"
SRC_URI[sha256sum] = "d8c1ca8528a2f208f3c2ae28cd2599888a86541533bee375e09adfc8add504db"
