# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "affa2259f5fbadf6f785a41df2a30d74"
SRC_URI[sha256sum] = "9e7d29ffb1fe80bcb14bb9b4666ea6bcbd0ad94776f5c8e62dc8f0ce74225efc"
