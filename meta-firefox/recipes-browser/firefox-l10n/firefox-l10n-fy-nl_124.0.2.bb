# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19e24af8c0d4b39a8af8887c700ff07d"
SRC_URI[sha256sum] = "0d53f52bd90c9cd93345a602286518805f0cd3e3a6ceaac09ed0ea77cb8e07f1"
