# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c233585792f3abb49ff5d10dba7a04f"
SRC_URI[sha256sum] = "ded0c68eb3bf5d03ea41222fec3bbaad51d79d5bede3d30f2c7a57e4f9687d5a"
