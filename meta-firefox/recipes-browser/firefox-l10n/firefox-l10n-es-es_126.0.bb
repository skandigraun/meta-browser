# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "537d0fdaa8012109dd09fa508a9c26e3"
SRC_URI[sha256sum] = "bb85c9c2cb323865d841f339ad97e19266cebda1e9eca907ef7daa36615561e0"
