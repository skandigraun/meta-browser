# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ee216dd1aa45f0fcb7ecb9bdc768fef"
SRC_URI[sha256sum] = "0041244ce6499f0e0d6530e16f41c018c075d53fc47059515e3c4f48d59055d4"
