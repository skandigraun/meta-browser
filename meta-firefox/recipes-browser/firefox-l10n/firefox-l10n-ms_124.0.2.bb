# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c37ad5675ff51518a6dea22913e1005a"
SRC_URI[sha256sum] = "96b52b913fd752b5df9e6d29682829918d1a1676831ac6d4104e9f0723f005f1"
