# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc485d9ee835b35d8c1674b1adc81a75"
SRC_URI[sha256sum] = "aefeaddac87413d83db6f819758793125a056d34bb805984b43b364a2bbaedf4"
