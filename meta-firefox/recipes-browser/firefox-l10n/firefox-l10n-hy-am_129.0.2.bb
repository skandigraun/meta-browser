# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e595f257380c31b8da938c11e5965d38"
SRC_URI[sha256sum] = "5c829c56269f032c825791b78ea946f8c049f6aba86a874f8ce8fd5994a4a422"
