# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9dc38e33dcde63a7416c6865979a8c3"
SRC_URI[sha256sum] = "0ba8534d5cefe0bb9cd4afaa2e414115ba0055cc3657c6e2b7573abff713eaa9"
