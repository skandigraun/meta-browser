# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e4fca18785a5cb420af7a10c0f05c4d"
SRC_URI[sha256sum] = "afe3f638401093d22b0576825e681cdb3270a79caf40b7d89a478442afedc792"
