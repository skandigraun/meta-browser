# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c495b14d54c7e2032ee5aa71ef00cc40"
SRC_URI[sha256sum] = "96b9682ec237f63797ed4cbec3440069f457b33db63ea723e6aacee9d66f0352"
