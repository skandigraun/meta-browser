# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8510e7d23d9f797943baf7628db64c22"
SRC_URI[sha256sum] = "e73c37b105a8864654138bb6ee4d8b1d9cefcbe990cc0f8293a57da1718f27b4"
