# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "302b538523ae3736ccd8075c4bea38ad"
SRC_URI[sha256sum] = "09f50fc85c3b7062b5177532fd145a3f3b7c061759d7fec38a2e0bf628d824e3"
