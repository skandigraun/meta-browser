# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cb45b5f01dd1160248e7a70536767e7"
SRC_URI[sha256sum] = "f1bab7c5b208ebb5ac87a5006a236fe09727be260bdd3b0f7b520a0ed91366d8"
