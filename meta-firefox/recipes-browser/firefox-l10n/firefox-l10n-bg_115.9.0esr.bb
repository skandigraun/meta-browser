# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90111d490b4dcb670a6dc49c6093ed53"
SRC_URI[sha256sum] = "f480dafeb2a31c1e5c8e807ae806d4dd6e50ce65ecbdc0cbf1e2f3dbfee676e5"
