# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3d85f79150e73ab0429a3b931f089c3"
SRC_URI[sha256sum] = "60a545cbc3da1414ab31bdd8d41c28393ad5d0d1b7ff7a42ae8bc5e0e401e9d1"
