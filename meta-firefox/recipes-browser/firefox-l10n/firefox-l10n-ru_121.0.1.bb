# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "289a7178dc20e1b94f1d4fc51486ed83"
SRC_URI[sha256sum] = "2e43cfd0b86824c958ed33f387fd40af7088383f97da1f5b3663401f64d06fd3"
