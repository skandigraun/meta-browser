# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f567b1f21a51dcfbd7178c134378fe51"
SRC_URI[sha256sum] = "c52b86bbc2c6394debe4711661e6796aa05e6d46058998c6d08a9886661c70fb"
