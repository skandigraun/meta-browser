# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "481d233f4b7843d0d430912210bce0c5"
SRC_URI[sha256sum] = "0de80c628c6cee8f490c4a2d1e88452a42f3d854fcaf88b51cf09ef11534649b"
