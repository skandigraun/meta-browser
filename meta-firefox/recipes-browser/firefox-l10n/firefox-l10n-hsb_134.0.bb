# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f97a992fb43d8f31e10c6683ca5f804"
SRC_URI[sha256sum] = "83171d5170af27a64fb4997d543bb1136749dd5fe73eb6ed0f642bc62ca9f66e"
