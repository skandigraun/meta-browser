# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79ddde5f1fde2b4365483d05de87a133"
SRC_URI[sha256sum] = "fc84be53e6300ab0e9bb35510dd6c1d6811f6475a266fc38c18b49c4564c6edd"
