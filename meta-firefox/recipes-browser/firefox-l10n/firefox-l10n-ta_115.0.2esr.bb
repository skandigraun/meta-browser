# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b9d876b92633e482a40dfee142abe4"
SRC_URI[sha256sum] = "8ed02c1286edf7b9c74e51890409c6eb1d99ace2d0f7631cda8549505f8bf41a"
