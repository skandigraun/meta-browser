# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bfc1f539fef184d132e4c53e322de3b"
SRC_URI[sha256sum] = "094e8f9ab66027647f998e1c5e13210e6c2fedd6b1cf4a4e260617d1abccc059"
