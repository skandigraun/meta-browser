# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f39eeff32c37a806c5f77d3368607bdc"
SRC_URI[sha256sum] = "6fcb44e2207ac66bdb83519d11360776993813cdb96790909674f7bb7513ccd8"
