# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c4405c47780e5009513c80885d7edab"
SRC_URI[sha256sum] = "64ff41a68047a434b3872ab3630e8be7a1adc98fe7d8bc2a361373bc04970988"
