# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f383ddf6fe69d89d462458aefbb044"
SRC_URI[sha256sum] = "472627e2c9439e5c6166b9e13216c34edac3b299ac8d49695faf966f8c284ebd"
