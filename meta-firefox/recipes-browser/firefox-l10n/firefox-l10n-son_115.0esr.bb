# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96f4195a2d915c7d207ab46b928a0ba3"
SRC_URI[sha256sum] = "2612dcc84b3cce34e9e4d33868813f3d9f0345894c8b13ff8af6f282bba1c39f"
