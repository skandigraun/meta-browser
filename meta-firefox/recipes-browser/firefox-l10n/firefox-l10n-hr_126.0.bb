# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3074b5516514adb768bb95b1b0a5d1f7"
SRC_URI[sha256sum] = "2051e2c7eb576ad5a18f197e972a6363c86c52eae89b517967c475354c4fa07c"
