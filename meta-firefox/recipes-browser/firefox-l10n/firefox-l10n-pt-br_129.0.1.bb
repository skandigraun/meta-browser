# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9e617dbff796c4b7e70f51e9e844f45"
SRC_URI[sha256sum] = "a516e104f1ec1249d1e9ad1bc19357be96044a6f9930d836017877d4a37b0df8"
