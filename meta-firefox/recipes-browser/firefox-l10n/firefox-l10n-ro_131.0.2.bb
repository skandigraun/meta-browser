# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bad1e65f86219cb2446350b42a239b57"
SRC_URI[sha256sum] = "02fab357b8f6726e6fc1eea5efd390529b29e704998bd468ff7bc35d73b4767f"
