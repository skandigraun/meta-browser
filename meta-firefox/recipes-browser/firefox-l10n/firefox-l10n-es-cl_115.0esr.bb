# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51c40c4518158c5198b314935f6f05be"
SRC_URI[sha256sum] = "b3c79f9fd20428671e303e6882d249bae2e7c9ee2113a28a146ef9d99afab562"
