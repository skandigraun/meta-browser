# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd14dd77098a3f17291f9c0b4679b0b6"
SRC_URI[sha256sum] = "636fb80cd610900c36320d5f477fcdc4f5d1b6838d75b42a5f8c84ddc5a6ad82"
