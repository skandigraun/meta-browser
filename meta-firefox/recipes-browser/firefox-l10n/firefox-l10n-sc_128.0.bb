# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e8853aa32669049394473e902184c52"
SRC_URI[sha256sum] = "c33d1aa350bdece9a40814e23a4207eeb4f9a9a5717ab4068059ac7fdb72baf6"
