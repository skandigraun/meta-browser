# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bea2b66f2b8c4aa930bed001e951520"
SRC_URI[sha256sum] = "3b96130447c37fbd8c6aae3f1d884604cb3b4c52e9de1cd335e834935af64dd9"
