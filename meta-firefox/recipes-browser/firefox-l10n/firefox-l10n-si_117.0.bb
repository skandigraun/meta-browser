# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "681dd8571ea12e41bd0f2439888bc481"
SRC_URI[sha256sum] = "5f5b854e9952e05761d323cb55e6391554586c3b6aaac1af33b42d68ddf99430"
