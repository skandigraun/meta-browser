# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e778f22785e6a1c4a08acf8cb4b2e04"
SRC_URI[sha256sum] = "df7879277c8638ec8850d8e04772468705f5cbc87aee1fdcdb66de2b3ea4b6dc"
