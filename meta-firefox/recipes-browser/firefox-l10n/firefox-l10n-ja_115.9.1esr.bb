# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91b478e9ff289d69d0dab3bb936f142d"
SRC_URI[sha256sum] = "ea97f9479ca023fbb40ead17e626f191b33bb27365caea0069b8258719938e69"
