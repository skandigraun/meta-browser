# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "617019d7ac2669babae9617547c1d4d5"
SRC_URI[sha256sum] = "86afa140cb1ea536ae9c6be146a7005e872bfe0c36327513cd16517fd906bd20"
