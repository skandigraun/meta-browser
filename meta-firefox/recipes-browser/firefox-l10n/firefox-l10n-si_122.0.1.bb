# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90e7e94ea5477e17adb1b7fc8af05c06"
SRC_URI[sha256sum] = "a6605a8cf898242c7642be6ee91c2347e7008a9a70a6a5cb095965bac4f9f289"
