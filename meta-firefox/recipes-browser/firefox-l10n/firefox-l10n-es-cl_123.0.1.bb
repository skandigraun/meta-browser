# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fec6743e87cb84291d0b233f327ff25b"
SRC_URI[sha256sum] = "8ad6dbc413091cb5a7c8c4f20d61eb4e9bb05ea10c05a6a0d8572342e88ca7e9"
