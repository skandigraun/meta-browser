# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ed43632cf074346b48392024b0b7f3e"
SRC_URI[sha256sum] = "5b6c7caae632fcd420036abccf7e4b5351af38cff14dd24499c97f3f5a10c8e9"
