# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22137a1f8e39dabf707f6cc59b0cf637"
SRC_URI[sha256sum] = "387046de44e2ab74309a32298da18817bb3ec43ba91b456a02fcc3138d02adaa"
