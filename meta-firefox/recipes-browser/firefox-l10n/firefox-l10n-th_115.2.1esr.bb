# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd9df1c2750953684b61208f2dfc6466"
SRC_URI[sha256sum] = "4f007ba5fa88eef4a6154b7a2ffd32acbe56d1be59f2b3907e692a014dd1a8d3"
