# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "149f30c322731acf868cefefe57f8deb"
SRC_URI[sha256sum] = "eb0902f8812c168c12366ae8e43aa7e551c960a97e1021f357f950b0d0b6cbff"
