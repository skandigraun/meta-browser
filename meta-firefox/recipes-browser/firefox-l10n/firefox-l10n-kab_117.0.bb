# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c39f484d67724cc1c58e78f0c0f3b45a"
SRC_URI[sha256sum] = "546e0b5dab3f0c0bcebc36670e2c3064032ec143e849e39ffa480addeb41adac"
