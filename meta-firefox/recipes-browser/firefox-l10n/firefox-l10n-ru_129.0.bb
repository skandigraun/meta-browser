# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d13b826278e1c95388180dff2596f22"
SRC_URI[sha256sum] = "13a23e941479f15da75b94df78a017cc2bcf52960e12255ccc63939f665c6399"
