# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2909be38b4f0452eb200dda150cddf0c"
SRC_URI[sha256sum] = "bfd7a6843ebe25c39b87c66415ea850d38a6071740c6918697664b0c774732b6"
