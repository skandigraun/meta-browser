# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd2f79fc99e60fff986b9645ee10fb91"
SRC_URI[sha256sum] = "35bf66fb8bdaebe0bb19f53239951e00a29337cef391007eb7b40920ff67eba6"
