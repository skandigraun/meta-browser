# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc353285bd47ae072dd19ef443c02e5d"
SRC_URI[sha256sum] = "7294e83f9252985d477f16930983d909b7357a137437d9dcd053afc6a34d9f04"
