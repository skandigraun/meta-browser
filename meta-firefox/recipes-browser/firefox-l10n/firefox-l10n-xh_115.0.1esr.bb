# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4acbdcd853d6321a27f9a0aa47002b7b"
SRC_URI[sha256sum] = "4e50b4b055e90b5c173071598842618e7d6b1fac5283db35cf451ee0c1b4ff10"
