# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74327af94db95ec5023b618711a812d5"
SRC_URI[sha256sum] = "83999dc10146c0d648061cc15cdfeab0a251cde892704bc76a5957bf92a7702e"
