# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1b220f0058491297e3fb0e386e9f76c"
SRC_URI[sha256sum] = "feadf0e8575449e6e75b5524325a8e4f07a2490e2070c83da30bdbec916d28e8"
