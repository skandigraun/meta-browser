# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71ed57ef815536032dedbe01449ca908"
SRC_URI[sha256sum] = "d660f130ad7fed0618f81e27ce49f08ac6bba15c0e235b32dac4ff11515c54c9"
