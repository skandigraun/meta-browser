# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "021da40f21e93eb3499b827fca249c16"
SRC_URI[sha256sum] = "38fb1921d9debef82c808acd74ff7e1e5f02adb968b5eb7684969101342d0bde"
