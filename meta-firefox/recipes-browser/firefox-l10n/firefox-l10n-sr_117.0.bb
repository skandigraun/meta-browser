# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff18eff9401aebb1870ed97761160bec"
SRC_URI[sha256sum] = "2e38c8db3e18ed11b0a6f0b918746a1a6783e53f61ab12e5dbc062d8292dc64d"
