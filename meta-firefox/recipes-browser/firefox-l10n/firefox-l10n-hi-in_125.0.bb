# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbb1a498ed91dd02b4ce3a89a15bc774"
SRC_URI[sha256sum] = "567521aeffc46b1575715692d21355369d2ca1f3a56ece4bf6620979b2116d88"
