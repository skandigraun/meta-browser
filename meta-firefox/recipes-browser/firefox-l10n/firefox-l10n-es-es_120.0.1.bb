# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04de93c4f663f17196eff0e0d656e346"
SRC_URI[sha256sum] = "92c3498a3d7b000912d1da06e11e9ec35bf50cb134631c18c0d54f8ec02304a3"
