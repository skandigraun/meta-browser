# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe94e699ab02d509998f624cceec905f"
SRC_URI[sha256sum] = "87b6f7a8885d960525080c70e02fd35a45c737d429fb4328a01c1cfc4e4dba52"
