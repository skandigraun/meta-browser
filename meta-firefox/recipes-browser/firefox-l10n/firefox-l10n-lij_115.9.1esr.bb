# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f28b56390c1c45bcf80fe60faad91f61"
SRC_URI[sha256sum] = "9ca74ce7dc6c178fb3aaab406600d67812a29c36b912f22921d43b4c353dbe16"
