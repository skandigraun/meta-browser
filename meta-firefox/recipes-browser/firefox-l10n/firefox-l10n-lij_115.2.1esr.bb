# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67ea432d5d62796dfd990e0a65c19217"
SRC_URI[sha256sum] = "14d8f3a49fa4097e409422ca7522bfedcd2072d8a3fad3afb6bda9b8e85f7a1d"
