# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1689cb01c19fe4cab30b70a3c281bb5"
SRC_URI[sha256sum] = "d7d2e1b9832dd9b205ee4835afa8632a2ea579494a88f635801be6749d6ff5b5"
