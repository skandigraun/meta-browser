# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6001ba073670f84defccc590243d161a"
SRC_URI[sha256sum] = "2089fc65610532f9eb93ee9fada77c94df5a25fc873df153efc4ac0241b181d9"
