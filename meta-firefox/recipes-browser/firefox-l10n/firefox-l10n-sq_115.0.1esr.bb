# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b56fc4b8f7926247af5805adbd9f7864"
SRC_URI[sha256sum] = "ab8193ee4eb692a3ab581f23b18f8dff49aea80fb7452e94af68fb5852ac87fa"
