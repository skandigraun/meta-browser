# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cc9b89e753ad4f07dddbc8dc58cd655"
SRC_URI[sha256sum] = "91548b05ce2aff1df96757fce334a613ae44c92a24b8e41890d4c7c988ae707c"
