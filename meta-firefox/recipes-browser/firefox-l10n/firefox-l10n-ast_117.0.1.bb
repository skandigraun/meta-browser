# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7aa6a6d8a55f16cf14b7de3c78ea3a0"
SRC_URI[sha256sum] = "11bdcd40ed2faab91a2dd6804fc87be3757a7eca845e9badea42a1cb2fbf5308"
