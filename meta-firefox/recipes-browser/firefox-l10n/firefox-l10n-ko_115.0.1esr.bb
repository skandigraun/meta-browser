# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3b90b906892117f292ee9abb941f84f"
SRC_URI[sha256sum] = "ec6cc25d02ffcbcb674da4537490edc9e6683defdd083ff86eea30c5623c009f"
