# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbe3eba60ab783c62748e27d2a1d9f3b"
SRC_URI[sha256sum] = "327f7c5de8d8c8d89d4d77856f5510a36780a7c3d0073bc9063ebc12f60efbf7"
