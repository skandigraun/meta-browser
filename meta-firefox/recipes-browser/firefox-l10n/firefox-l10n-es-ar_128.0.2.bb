# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce1f8400202a8060950e4c6fa54532a"
SRC_URI[sha256sum] = "6a96eb0cb785d1885a9eb3c829e9e8bcf8aa95db98beb02bbdb3e4511985c84d"
