# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99ed2b3087910f04205672b69e5ae75e"
SRC_URI[sha256sum] = "4247005319b350df3be19ddc47288378aeae2539c3da109fb352e8b46c8806cd"
