# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a82b2c84d5ca896a5acb7322617242f3"
SRC_URI[sha256sum] = "ed4af640b42f0548f6ce335bf69cc7a51ef3a05a9d28f481a24dea7768a5f75c"
