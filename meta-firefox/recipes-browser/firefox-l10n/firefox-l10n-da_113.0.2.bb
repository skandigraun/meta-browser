# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "165ca9d9c339d2f1831e79fcda1f5146"
SRC_URI[sha256sum] = "c529ba7e1735dbff467a79f1854e9207448c366f7e7626172169bdc1a58f0fd5"
