# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0df01b7bc5145088016510b2b0e09694"
SRC_URI[sha256sum] = "2008c155b81ae50cdab9e6161f5ea6e948ed9bdd40a82d8971aa5be3b0440e69"
