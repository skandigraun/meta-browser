# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88f70c03f011dc053b1c92f2d2d0d551"
SRC_URI[sha256sum] = "eb4c025d7b0ea4dbd8b498d0586f990c9172845fdb4ed847dff5c7cb9ec7009c"
