# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e653dd666ceba8fa15638ed3c254e0f"
SRC_URI[sha256sum] = "7aa85724f5b31d31c3108700bf0d2efca74105c5e0df72c6a79b1913f5058152"
