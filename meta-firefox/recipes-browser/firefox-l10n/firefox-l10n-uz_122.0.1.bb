# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2d1d7c7e117c42d41d2b91980ae4f91"
SRC_URI[sha256sum] = "300a5bd4b4ae330f630dcfcb0705e892286a5e804e3127c1a3b00fba7e5769e7"
