# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d30a869b3ee53280b96e442932e1f075"
SRC_URI[sha256sum] = "d18def392c0373e76db09629f497f2ed5a0bfe2ce68a09a5a6f7b8bcb00c4ad5"
