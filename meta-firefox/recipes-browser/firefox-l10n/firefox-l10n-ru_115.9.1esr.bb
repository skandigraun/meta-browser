# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f5074f9a8abfe107f6295681beab366"
SRC_URI[sha256sum] = "18351ab0e7d49ebb973e7f2bc09267c0aa98ae7b9d8161c22dafca80c7f9564b"
