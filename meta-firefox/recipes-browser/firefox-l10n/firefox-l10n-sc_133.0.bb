# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1814f717a30d38478423de9c4d659fd"
SRC_URI[sha256sum] = "e68e338bcd4d68adde86189cc2ab728c5f595d84f046eec7f9a741aabac8fe5e"
