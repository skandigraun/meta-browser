# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5da1717adc8934755d74e2b19a0aaecc"
SRC_URI[sha256sum] = "21e12e2b7d974b606547ccb6d3226477b98d3537cb9a1aa01bec358cdf069c79"
