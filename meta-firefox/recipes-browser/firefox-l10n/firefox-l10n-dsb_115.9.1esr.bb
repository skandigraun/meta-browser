# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f25784ab52cdfe05f7edf7fd0bd6f11"
SRC_URI[sha256sum] = "d2c1fa4829923cc7fb6f4882b1bce149ea3a7b01aeb40e45120be0db04a04b78"
