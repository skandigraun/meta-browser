# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "835b98fefdffae75d1af5d6c0e83e614"
SRC_URI[sha256sum] = "05510ecd11515ddb44753fa603277c048c39eb0599d7ea689d10cb5e10393d4c"
