# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83dc7acc7b2248f30aa7ace465a3aa91"
SRC_URI[sha256sum] = "396404e7cfc8679718bbb280021299c4678acec9bedfe9f0c671cbcaed2a7d62"
