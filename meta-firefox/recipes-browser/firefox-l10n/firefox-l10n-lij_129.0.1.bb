# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d37d2a2d0fdca496a0332fad465a3b2"
SRC_URI[sha256sum] = "8843e3cc3ab50922d1b78fef73d1cb93dc3a6fbe2d553917e325312771a665e9"
