# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c22f46745108dd807375b1eeaf6e19d"
SRC_URI[sha256sum] = "342230adbb31f5e07b5a89ded0bd860fe76a1cb638953383de5c690fead75050"
