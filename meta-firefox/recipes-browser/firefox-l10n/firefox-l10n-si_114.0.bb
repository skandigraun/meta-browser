# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37ba7ca1593a87c0707cf00c9dfb8db9"
SRC_URI[sha256sum] = "b8d14e07fdbd034d4241de6a77c6bfed38b54726ec770ea25442a947fd9a821f"
