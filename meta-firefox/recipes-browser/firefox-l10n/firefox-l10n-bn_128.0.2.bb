# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db0393377a6dcdc8252d0fe7118e5ea4"
SRC_URI[sha256sum] = "2ac35ceac920cb62e20de112ceb2300ceba1372f2ec2edaca1a5f9268cd955f7"
