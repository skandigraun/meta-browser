# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b89bcdf8a966aaf2ac9e6722e04d3b4e"
SRC_URI[sha256sum] = "5d0d0da91debaeac0a2f83da7e398b42c892d3f7b3f3359d87f71a2abeedb571"
