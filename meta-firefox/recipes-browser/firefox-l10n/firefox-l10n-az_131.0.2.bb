# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf9e0c87a2fcd4cec671dff6d540d45c"
SRC_URI[sha256sum] = "aea7a3306db19998889254e864f660e42089869868924c306e2a56577dd68948"
