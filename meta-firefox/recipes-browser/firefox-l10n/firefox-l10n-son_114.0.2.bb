# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1b09c6584a02efc80209fbaf1da3873"
SRC_URI[sha256sum] = "708575e9e08368ffcf66ebcd32cc62f981addc9b83a92c4b43357254bb8c3386"
