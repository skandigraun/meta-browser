# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78c0ab32f53670ed7edd2a44d3e61024"
SRC_URI[sha256sum] = "d7df23c2b796df0554d50ba28e2ed4c9c41dccd1325eb42fa99de7189f80a98d"
