# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac0b85ffad180245b1a9faabadb5c9d8"
SRC_URI[sha256sum] = "dc217c25048152b812e2b17eca24e9b560e626f5b5bc66185bd8697549dd0c99"
