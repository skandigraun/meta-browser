# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "067b0bf9784ce86b2f8fb53fe2f5e1c9"
SRC_URI[sha256sum] = "68803debb9336a4aff37bcff7e64471d5dadbbfb68e408b98fdf7e23f8b2bc2a"
