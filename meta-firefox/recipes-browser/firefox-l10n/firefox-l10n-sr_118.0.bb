# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea2d69b1064618df3ff91c168b84812e"
SRC_URI[sha256sum] = "69e3b3769f80b98446c27b6119704c30a08617a6835569d48de3b4e1b0cea04e"
