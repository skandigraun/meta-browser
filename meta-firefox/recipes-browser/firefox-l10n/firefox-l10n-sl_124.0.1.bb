# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "951ebef049d5fc5a998321f90d1a2be2"
SRC_URI[sha256sum] = "fe68e39fa9618608d6d0d6139760c2fd3a73ed5f7757db839b22d95ccdbbc15e"
