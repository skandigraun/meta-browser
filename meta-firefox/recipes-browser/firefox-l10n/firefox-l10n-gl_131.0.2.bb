# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71873e39d27213ed5d70cb033cc50c52"
SRC_URI[sha256sum] = "86572777eafd508f138fe5f94db85ad4eebf8d62a5464389e696b0988cd9d7ea"
