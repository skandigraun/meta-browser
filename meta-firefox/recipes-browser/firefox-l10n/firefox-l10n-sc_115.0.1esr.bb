# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dfe4d0316e3533ee41a64f31f18bb11"
SRC_URI[sha256sum] = "2dbb193f7ba2edc085452728f124ec1ebd8aa52087b09675e10dd788e69c6ee0"
