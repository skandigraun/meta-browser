# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6be389a0ae3e86a6a5bdf9359e1f5012"
SRC_URI[sha256sum] = "46c0f90f13a7093c0ee8a1defe1e391c3775850ee9e05f0f32fb2fa68bca6777"
