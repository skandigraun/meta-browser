# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a297303772f7b4e3dffa2a075f9b28c2"
SRC_URI[sha256sum] = "114ce31b68a3d0d3bfb23499df498c64f258eeefc2a8ca2f4d33d92432b71dbc"
