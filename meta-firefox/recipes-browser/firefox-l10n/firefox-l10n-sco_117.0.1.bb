# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e7cf1660c3a9e20b36473d3c8b40571"
SRC_URI[sha256sum] = "b17c3598ca8fbc7a82484d39e6150bcb98bcdbd2864b9a3fca48458f0b6d69ec"
