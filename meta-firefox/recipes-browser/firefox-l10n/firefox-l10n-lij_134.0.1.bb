# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96ace832661f72ad2186bb817a48d0ff"
SRC_URI[sha256sum] = "86b345123b762512ae0c1e679a3f373021c08e34b47a27a73bde70e4e52e52ce"
