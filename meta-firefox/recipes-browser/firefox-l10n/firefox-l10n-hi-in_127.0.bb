# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34fcca4cbc2626ce98344c4ffd140160"
SRC_URI[sha256sum] = "06cc9d0328cec0d26a0416a2b5c209463d90fac5c2dec69865b819093da70494"
