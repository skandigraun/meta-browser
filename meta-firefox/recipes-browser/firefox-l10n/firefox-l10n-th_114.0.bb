# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1a0574685ab69ee6f6b11c6fe0e3c71"
SRC_URI[sha256sum] = "a0d85d09f3bda6a1416240a252ec4cfc916cf37b98c72185a6b97e3b7b50251d"
