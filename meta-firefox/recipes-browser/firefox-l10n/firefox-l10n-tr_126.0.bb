# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d39cb019b54a75df339bc9729a962fd"
SRC_URI[sha256sum] = "7683927e5183d5ff98770af0f246448b7759c3d55f84a89bfb1dc413d7fb759f"
