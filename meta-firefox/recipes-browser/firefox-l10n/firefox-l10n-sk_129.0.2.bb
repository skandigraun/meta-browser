# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eef76cd24ba6f7540a523820cf30046a"
SRC_URI[sha256sum] = "814165800f389f9860bba481323cd94f3bc496e4d8c86ed6662870d0c61123f4"
