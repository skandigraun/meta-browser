# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c36e2226f4e7c1891e34bbc8b5845e5"
SRC_URI[sha256sum] = "a7c80106682826953ca7c1972faff8c7149910e1928752a5d35d998bbaa03485"
