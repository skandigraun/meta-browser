# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9c0e04274a528ff95dbffa6c8c65d1a"
SRC_URI[sha256sum] = "0ef31d95b67d8d9bc0e6144dfaa23cd1ea491259a8a54d8a5df85e96764a3498"
