# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87e6d53cd8a688851e2eb067aa6fce6e"
SRC_URI[sha256sum] = "9f8616c69ff2fa4dc5c33ff8607fc3264f78f4432996ecb410ed6666c6213747"
