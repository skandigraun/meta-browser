# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4098c7180412f17556fa2734f7b80c09"
SRC_URI[sha256sum] = "79a3861ed70b7fc99964a23c5792e0ac3693c58f9aa5153a3f8b11c52f4d50fb"
