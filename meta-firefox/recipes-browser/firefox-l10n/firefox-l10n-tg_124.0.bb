# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7a4fbbfcf76952681448424bc27934b"
SRC_URI[sha256sum] = "f616ef778fb4148ef8eb78d8ac91d1aeddb8bb183948783030639b9ebdb5c557"
