# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e069d344c660f1cb0da02b7f854d9ef"
SRC_URI[sha256sum] = "da58c2ba13252a42551629e66771e8254fdc4e80fff7e7fab40baeec8adc201c"
