# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e552759cb3327c6436dbc7165187cba"
SRC_URI[sha256sum] = "8086eab0dc340f16207a8e58e35ba6051697369f8ec0c562f628c674be82684d"
