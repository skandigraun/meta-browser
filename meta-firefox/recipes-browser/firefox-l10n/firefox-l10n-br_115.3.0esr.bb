# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8c69d7bc709a2c7c266029abb595ee3"
SRC_URI[sha256sum] = "0deeb09b99e4dab1c341d7ca076791af61c9d3ca90b3b4b9be73cabfbff25434"
