# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5b398d4634c747129dd55654b0ea394"
SRC_URI[sha256sum] = "1606169866df38408f1d470b84fba23fd8bf93a06ee5d0e44c930f4a5e847821"
