# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c008f764ad245fce7a4cc6d7bfef0504"
SRC_URI[sha256sum] = "c8dd16314487012ffeb6efdcea39deba7371678af47a9961031b7008f11eb60c"
