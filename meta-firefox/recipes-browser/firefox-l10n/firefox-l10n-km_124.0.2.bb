# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1944352fa3831ab45815d7794a28c1d7"
SRC_URI[sha256sum] = "0863615da71fca86ec8aaf04a19b86ddef9dc6cf5bb73ad7f0bb17e8dccc8716"
