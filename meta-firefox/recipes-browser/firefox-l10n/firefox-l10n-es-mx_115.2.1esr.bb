# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f11559a6f87fa87381a5dbb554c7fa4"
SRC_URI[sha256sum] = "a5d836fc9600386ee99f599f3e21fe4d75baf19a609fb0e3ed311ebe8f24f92c"
