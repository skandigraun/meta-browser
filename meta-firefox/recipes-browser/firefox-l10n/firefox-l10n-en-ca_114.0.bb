# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b15e86f25b9b72d9142d13d424f17710"
SRC_URI[sha256sum] = "9ea3dc01ba7d9389d4514626f5cb1597063f7e68401ea13522a74ac777cde4cb"
