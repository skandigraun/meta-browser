# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb935529f9c260cf4d5dc24451842743"
SRC_URI[sha256sum] = "51c63261fd120b2dbbf5b8e0fe6333ecf54ff208f27c85b19b799524155aa4d1"
