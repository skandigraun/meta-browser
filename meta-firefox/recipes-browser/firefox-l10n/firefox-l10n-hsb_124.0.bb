# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64bbe25c74200896dc426ad198ac875f"
SRC_URI[sha256sum] = "af9d588f99fc9968f3a029f041baa9d8b04c070570440da85854d2270ddc3fe7"
