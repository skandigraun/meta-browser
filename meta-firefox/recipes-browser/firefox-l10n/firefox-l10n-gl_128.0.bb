# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82973e7833a468565a0f4d5db098714a"
SRC_URI[sha256sum] = "e932a7a7505dee3da0bcbadbbea41ffae0d762c02920a60b787704aa33fd9db8"
