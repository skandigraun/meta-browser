# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b68fd3f18ba3c432f3690e4cdc3a041e"
SRC_URI[sha256sum] = "6cbe58137d379a34db1344336010776ab7e13bd2db186602640f6f56b6d4ea5c"
