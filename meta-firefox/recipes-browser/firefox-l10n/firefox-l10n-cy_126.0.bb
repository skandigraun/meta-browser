# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77ed1adf7578224a1f00e2a3ea663cd9"
SRC_URI[sha256sum] = "ea071f9cd6b4ad3f41c8324ca83d51bceeb9c6d030d1a702e3273962be977077"
