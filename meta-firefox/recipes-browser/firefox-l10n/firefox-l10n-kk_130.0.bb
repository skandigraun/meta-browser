# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40b49780ad40aeb4084f7275b247ec6f"
SRC_URI[sha256sum] = "65ae1984973f2d70e71e61dc4ee65be28e52c79ee4622ab27447863d38737d65"
