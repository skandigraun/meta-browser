# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6219e4a5bddb9e2900ccdb2672ecf97e"
SRC_URI[sha256sum] = "4a2bdf885ab2d35d56cb772a913cdbe5a7aba61b02feeaa8e98977d54b4b8a8b"
