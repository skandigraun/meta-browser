# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cffaad3363c1bb790c36a2d5c658827"
SRC_URI[sha256sum] = "76a358520c5e7975825f2b4ad4d645eb22f0513bb593b70da3d1e4cca78157aa"
