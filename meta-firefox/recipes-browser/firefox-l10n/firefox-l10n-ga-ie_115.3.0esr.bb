# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4728055dffa92c91d4e8f383c9e503d5"
SRC_URI[sha256sum] = "299a680a55c5acd1305a1285380898b9c4c90999d924d8b34aefe7af126890e5"
