# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5a1d7396d392231317bcdd116302bbd"
SRC_URI[sha256sum] = "1648b0896f30e87f5731fe1d26f78f8486c30493698de1c4cce230c1809143fb"
