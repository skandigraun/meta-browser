# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c8c1b946fc42a4197590f9708fc1329"
SRC_URI[sha256sum] = "e9b38b046bf83350d0119606abfa01de813dc7f15ddcb622ead123aae34cbf0d"
