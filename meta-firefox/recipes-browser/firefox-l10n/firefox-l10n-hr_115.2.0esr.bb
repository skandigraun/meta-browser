# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07be8e05d7c56f4d77f38574127db7f6"
SRC_URI[sha256sum] = "69ee090baf4567f0765ef29580d5b57e0f656a0890cd71fc2279697d796166a0"
