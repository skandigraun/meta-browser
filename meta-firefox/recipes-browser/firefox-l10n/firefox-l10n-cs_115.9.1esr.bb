# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ec09533928f8c522e8d4124fcfcb785"
SRC_URI[sha256sum] = "3a6b552d9ac14ebaefc9bb0fbbf4cd8ddaa650214924f838c18fd066bab019d2"
