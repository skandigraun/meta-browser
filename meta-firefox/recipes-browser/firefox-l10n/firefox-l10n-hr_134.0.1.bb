# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeabd9aabb7a3e227510d536bfde66e4"
SRC_URI[sha256sum] = "432197fcccf294e2df70cd4d6d5785197cc7fa4a8aced8d5cfa54cd80bd08482"
