# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40306e91108f289f0188ade5b7aff475"
SRC_URI[sha256sum] = "bfdb9cc771f371d51c49cbd2f29088ecfeb39a0a0c5c4c47cf9e056808bfbf9d"
