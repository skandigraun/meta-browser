# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de37a0335dda2b4423ed32606104b67b"
SRC_URI[sha256sum] = "ca135f836a00b39a8d0363469ba2dfa2e21ac2a954e4d875b3094fcf5eb74249"
