# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ee34e90cb2c61475649683e98e4e97e"
SRC_URI[sha256sum] = "3d13c9960bbf10b277039ca3cbe05dece5dff2d1662b55a928126222aa9d1682"
