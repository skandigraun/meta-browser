# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43b7e6072d861ed48cc01035e3cb16a2"
SRC_URI[sha256sum] = "10ff813f33491d4d19ae2c4188eb819982be6a41e1d67b18005fa6bf0f62f8bb"
