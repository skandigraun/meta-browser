# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "301c060fa66cf604471a3f78c1a51157"
SRC_URI[sha256sum] = "6fcdc8bd560309faa13801599b77ac4398286d52272080688a45b11ef9752daf"
