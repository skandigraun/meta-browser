# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb3cb421727c847c7add280e7f533951"
SRC_URI[sha256sum] = "23194b4592af28d895acf72ccfbfcc1b3ecef8b834394e3ab1f6971d62464f5d"
