# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e624ecfc2288bc2f86b8f1294da3907"
SRC_URI[sha256sum] = "3377b041a90b6ee603c2e038ffcdff1133833932e875110e3a651140b9363407"
