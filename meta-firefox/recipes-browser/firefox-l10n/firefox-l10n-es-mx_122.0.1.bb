# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88e987856f9c16b40c18cb780ecd3250"
SRC_URI[sha256sum] = "210f01caea8ad3df2d775ab9a5134cdd6d7bf4f2254b38c30133c492cf7d0bf3"
