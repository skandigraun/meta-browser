# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6c670cba90baf37253b40150ab760fc"
SRC_URI[sha256sum] = "8ac80433a8a8153396a2fd7255d0a93186645cd72bcd31842ef25d3101cb9e90"
