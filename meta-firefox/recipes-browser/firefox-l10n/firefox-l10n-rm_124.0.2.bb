# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a98fab71011c2e82f8bbfdc93edfccc"
SRC_URI[sha256sum] = "4c47aaa25df2db9975b5e7cb52d2082d9b54e19e0335410eb7e5664a23f4193b"
