# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51720e2aa317ae8e158fca9409f47914"
SRC_URI[sha256sum] = "1406cb8da942945a22fd5a7cfc0e3d9e15ea0e809263ef1d98be5b3b485e17e7"
