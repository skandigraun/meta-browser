# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05df9fa40387240f1d7f4175be6d1ae2"
SRC_URI[sha256sum] = "5257d3c564bd74e23fe6a3b5ce0ca8b9ee4eb02e0d6a1b6af6c230d56a8cc186"
