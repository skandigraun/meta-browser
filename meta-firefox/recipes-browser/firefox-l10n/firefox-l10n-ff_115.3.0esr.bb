# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9bca5809262cc3343465d93c1492fdb"
SRC_URI[sha256sum] = "84d3fff20c3ef56551538adb569350a5a0df3e6735c67c1978dc25a7f11d4f93"
