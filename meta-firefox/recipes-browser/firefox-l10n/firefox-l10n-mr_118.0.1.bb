# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd04731eeed82a9c2fbfa341efeef55a"
SRC_URI[sha256sum] = "265e4548125918e16d1f743c0f20bfb53893ba07feb7cee1695bac1d86eca528"
