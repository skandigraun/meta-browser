# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ab2907bd7f6c50a6cefbf08b1541447"
SRC_URI[sha256sum] = "0178285496e108d8ad17d5da419e30a47cb1bc8e0854901f256bd60a9e8d2854"
