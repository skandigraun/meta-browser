# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e573e2e01c9b2b158fe5ad55e9bfec2"
SRC_URI[sha256sum] = "b3dc1c9902b1784f255859af003bdf1b86370c04cce377f34501774959ee0eb8"
