# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71f473228d607e82915ab23bde0f28c8"
SRC_URI[sha256sum] = "f25549bd944b124090f46f347bb8bc1bfab034b54dccf4ed59235ccda5275356"
