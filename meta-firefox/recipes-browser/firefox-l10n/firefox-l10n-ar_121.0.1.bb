# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eef68c29a0f589757b8b10532d107e5d"
SRC_URI[sha256sum] = "63364c424ce8029ce5bdaa4101954e2dc4e067792444c06a408df71909f85481"
