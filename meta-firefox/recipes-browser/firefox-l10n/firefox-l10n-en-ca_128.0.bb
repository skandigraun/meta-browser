# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a00efcf88826042b5540b5039b03a362"
SRC_URI[sha256sum] = "8cd3682512479b55ccf55ac7303d04d20a12faf9abb6160524279addcd2cfa53"
