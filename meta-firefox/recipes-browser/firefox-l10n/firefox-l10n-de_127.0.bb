# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "025e8aa70c97c4260abb7dc3b3ad4f09"
SRC_URI[sha256sum] = "22b0e24059c7cac2b43e56ff9bc692a30b8ce60dcd9dbd231b3b0ab3f9bc564e"
