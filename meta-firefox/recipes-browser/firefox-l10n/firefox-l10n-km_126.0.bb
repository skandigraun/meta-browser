# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8ddf837d8611dc905a0675ee4629699"
SRC_URI[sha256sum] = "9f07c5382fbf684b1880370ec6156f4793884f1b02564e00f2fecf0148ca63cb"
