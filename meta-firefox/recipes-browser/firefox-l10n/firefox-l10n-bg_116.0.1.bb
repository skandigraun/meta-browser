# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05814843df01aab13303fba4cb21b00e"
SRC_URI[sha256sum] = "061a12330bde4d0f341ba3f1a9fa8886d69e5e0d4b4f7da7e536409fc6f11fb9"
