# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98e9c4a8abddff004fe04419153a316f"
SRC_URI[sha256sum] = "d412b806ecb7b15106c386132123c4ed02ab2e67af01af5a128282090d1c5b25"
