# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f91faf48302e822662665cb5c288857"
SRC_URI[sha256sum] = "ec2883a8492960b9c06f3e0f684292dc2bf490c37e0ec6ffdb1869d542d77906"
