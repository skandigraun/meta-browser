# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4831972df1154b83411d31905bc8df5b"
SRC_URI[sha256sum] = "f8d6470fc22cab52a3d3164e6e1ba42c5a2163665b4f9befd1e9c35301ccd87d"
