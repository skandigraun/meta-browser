# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b17db59ff64440375b4ffe0deaf4bca7"
SRC_URI[sha256sum] = "3e8b1ba3688c22840bb5299a6df02636115bab3654686b4657cd583c41ab776c"
