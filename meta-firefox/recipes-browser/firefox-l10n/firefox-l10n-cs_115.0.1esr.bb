# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f955ef01d733715a274877f4f2434509"
SRC_URI[sha256sum] = "6b7e3e4117d4325d96fa0c1c2dcc016822e92935063390aea420a81acb94be1b"
