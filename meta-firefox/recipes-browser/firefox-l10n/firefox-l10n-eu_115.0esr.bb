# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d07141605feb09c90a2818cf306a5de"
SRC_URI[sha256sum] = "ec1c06d7de2b9cea626f4025893b4e5af229221dde14e892645a55acb1b16351"
