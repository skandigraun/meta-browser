# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6d1aae073765c463a28cfb7a9f2720a"
SRC_URI[sha256sum] = "6106011b1c5422bf82d18acfe7ccaa666199395a4dec743a2d7f1f44d4fea344"
