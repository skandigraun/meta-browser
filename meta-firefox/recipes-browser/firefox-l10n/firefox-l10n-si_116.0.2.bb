# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8686b12f75b4256fd5719402ac1d04ba"
SRC_URI[sha256sum] = "22ab331652ad6d89b0c847018beecbc23ff80db970c8d6dbebf2db9f901ec9c4"
