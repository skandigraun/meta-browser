# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b557261495cccd9340a33cd410a5793"
SRC_URI[sha256sum] = "f14464fee583c0afe7022db7e6d5dd607782a5f04c9e0caef7dfab6ab135f609"
