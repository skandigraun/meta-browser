# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23d47ba17c2d84f41f16ae228b4dd0e2"
SRC_URI[sha256sum] = "a6089d247a26d629ef12e26090777c80baa95f7d223ed12957332fa39d3c67a8"
