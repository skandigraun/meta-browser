# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74a20e54fb227e72ff8fc18637553442"
SRC_URI[sha256sum] = "575d7a1a308e6abaafdead39ce189c3879d58c4f0d95cc6e1173d56913a25e96"
