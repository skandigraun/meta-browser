# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44d641f980d0090d8fa2ad61979f383b"
SRC_URI[sha256sum] = "c841770da81a30a36fab19c3df19c34be6c73ad0a8d5c333a8dbe4e56636a007"
