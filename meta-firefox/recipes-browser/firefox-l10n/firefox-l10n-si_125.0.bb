# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f663663ec6922eb088d8ca39e4709441"
SRC_URI[sha256sum] = "ed55df1398bd6531c0f7fb100c57a5b379736b3c5fa94028e89510404a0bbb1b"
