# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "298053118185296678ad0672721c8652"
SRC_URI[sha256sum] = "8abc51326f72ef418d3dc9be53c5086e1b91cc8358edb565b4f9972a9b784e0d"
