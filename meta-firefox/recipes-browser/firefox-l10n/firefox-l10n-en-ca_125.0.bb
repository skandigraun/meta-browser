# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c898a96f87c3d432e027c1871983e21"
SRC_URI[sha256sum] = "daedd74c7adf5338a75b6cd8425377c1f32249ac0a4c7b407130b7eed56f5a67"
