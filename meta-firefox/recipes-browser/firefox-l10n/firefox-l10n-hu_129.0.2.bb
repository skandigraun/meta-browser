# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "547525c7a4866c5d5f8f01cc56beca2e"
SRC_URI[sha256sum] = "bc3832b6fdb920ec2508991b67cac211d253580c207029dfeb99788608fbe655"
