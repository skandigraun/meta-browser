# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe07b05b39567f2898dd61f044250f8d"
SRC_URI[sha256sum] = "393d7f1cb9dad13f5d084edbc30096a81b9dd346088b231297f5805226ac6954"
