# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d46c8ba2a0761b0f15284fddb019a116"
SRC_URI[sha256sum] = "9d0a9674a6fcef7bc17c98b0236b5ed7b0911300c70cc124052d14514c784eb4"
