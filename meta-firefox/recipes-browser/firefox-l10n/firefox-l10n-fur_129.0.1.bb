# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2859ec6b2851fa0d7c0343e6d476c3e9"
SRC_URI[sha256sum] = "0cb00c24cf82038cf2ff5743a456f665d2d3feb90b0c9b1a9c7eb092efae45dd"
