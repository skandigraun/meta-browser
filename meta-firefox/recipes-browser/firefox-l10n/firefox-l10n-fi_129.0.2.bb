# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d255bbeb6b122c076fbe759f6e218185"
SRC_URI[sha256sum] = "398c5a042f95a45617d292c28a522203ee2feea6f1cfe1fd8b08bd5767cbbf51"
