# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6557a8969df0698ca9168a55782e6d3f"
SRC_URI[sha256sum] = "7a445b93bd7786b061689a7eeaf56db01a761ab294ec3930c9fa7a65b72c6968"
