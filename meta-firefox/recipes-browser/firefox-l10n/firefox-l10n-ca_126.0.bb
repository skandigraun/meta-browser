# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b972225eacc1346cd84bf2ff511fb85"
SRC_URI[sha256sum] = "ddda3b20975c9c87f9161da68202425172f5f2748fa979bda9ef788d6f2d3d7f"
