# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34a5b90150b3a77a0a276140add7953a"
SRC_URI[sha256sum] = "3abc212a43f87c36020c0335ae97fe42cb7071b69052ebd8a45f000fd5c07685"
