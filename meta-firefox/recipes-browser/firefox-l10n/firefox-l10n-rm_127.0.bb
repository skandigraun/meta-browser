# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd4be83b6df1cf8273918f2ef8aa666b"
SRC_URI[sha256sum] = "4d7d5b757d8d3be8f44d437d7bb414138b7cf3e992d182ba739fe72c05a0630f"
