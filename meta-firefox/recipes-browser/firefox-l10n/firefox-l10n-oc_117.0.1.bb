# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8b3e7d899f2ca7df2ea0043d3a406a"
SRC_URI[sha256sum] = "7dd1c54d4d05a42f53f4e74770f8065559815c5c85f9d8b50b0c86fe2d533a20"
