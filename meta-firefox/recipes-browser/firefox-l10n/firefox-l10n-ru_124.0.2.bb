# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da8508f8ce88a043c14071f156ba52c2"
SRC_URI[sha256sum] = "15b085351206dbdfe1ac55a760449fb11b25da3faa02047497fc625000becb84"
