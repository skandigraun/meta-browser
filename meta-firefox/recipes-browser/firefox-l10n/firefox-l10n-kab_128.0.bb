# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12100f85dcf940ee67ed5d2ef4041b93"
SRC_URI[sha256sum] = "a35254c6ac17d4cc76b8c3c2706133813b5bd07fc1ca5ba946af203ec436ed6f"
