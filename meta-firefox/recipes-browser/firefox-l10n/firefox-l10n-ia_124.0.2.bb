# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d5e8ebe2b691200f3a1e4453b4ee219"
SRC_URI[sha256sum] = "d0779b89936c6289fdc7710a86416bea54086fd9175c14339f18549ee817576d"
