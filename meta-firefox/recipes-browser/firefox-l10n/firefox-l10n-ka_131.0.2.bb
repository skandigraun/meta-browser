# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cadd7b6fefebfeda8a1d3a8188b2e34"
SRC_URI[sha256sum] = "0e3e8ef17a97495da71ea34130250ae5f766219cb840876c5d78a42c6756e6c2"
