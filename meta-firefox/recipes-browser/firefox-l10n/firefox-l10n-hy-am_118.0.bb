# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfaa3fb96ddc7fb43bc4797658538702"
SRC_URI[sha256sum] = "ca4ff5d2c0ed1ae3240e2f3f9f5de678075d60aaec0f0e4eeb340e6dc234c431"
