# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "429278804a441c46694483298d93f2ba"
SRC_URI[sha256sum] = "e5e1ae587e4528c402e62b474fa59954aa31fb666563aade8c7f959a486de192"
