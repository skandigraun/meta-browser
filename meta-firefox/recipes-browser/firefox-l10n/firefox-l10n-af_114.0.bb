# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1aea9e08d45dcd56ecab1125682e65e9"
SRC_URI[sha256sum] = "26e309adb10d6ee133a5e1d47d969b04da06a9aaafb915080ab6d039bd7c9995"
