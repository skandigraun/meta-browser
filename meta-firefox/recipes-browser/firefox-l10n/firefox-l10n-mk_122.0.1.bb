# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7077f053fdfa61565aaff5a224698aed"
SRC_URI[sha256sum] = "817c7fcb098782d3659154859741cd6649bdfc0d4cea4cc6fcda5738b965b4d4"
