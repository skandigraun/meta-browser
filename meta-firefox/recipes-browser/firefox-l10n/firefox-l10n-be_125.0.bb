# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "323a9d364ec32c59f9199a1670061000"
SRC_URI[sha256sum] = "13a07236ba7ca434079e93ac8c2ac443ed12b9ff1f54d16614e21048ff7876b5"
