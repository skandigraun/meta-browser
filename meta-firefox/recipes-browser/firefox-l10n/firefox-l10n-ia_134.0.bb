# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "668a58442e8c457c48c8014e3ca15ec3"
SRC_URI[sha256sum] = "1e61e7fe0f9cf01e5bb87e07f77771fde9db3fdba9015d2453cdb03b92866456"
