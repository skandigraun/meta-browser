# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a181e576b31cfe0cba3203c8d061183"
SRC_URI[sha256sum] = "de81238e02f738d852cb819325dcac3b4ab07e2e58619beab1e6a04c72ce4528"
