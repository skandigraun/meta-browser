# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b9ad00dd8024262fcb223063011938a"
SRC_URI[sha256sum] = "27cf57ee614f7dc8ea2df4d0469e71f6c638f139c197d289405eb2d13fcbb513"
