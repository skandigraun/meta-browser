# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db649ca1f6f3bb28f40bef9d58769d91"
SRC_URI[sha256sum] = "00e02078a43c7bf1c5edadb66bd628183c543a2fcd67abe04b9228c5d1772079"
