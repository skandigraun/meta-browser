# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a7c56646258559455c9c54c301a8121"
SRC_URI[sha256sum] = "0a3f685fbf5b2c9c7fae94a89e2ab00838e45ba7957cb135428651d2aac4d71d"
