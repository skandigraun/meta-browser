# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d3708334a7feb6dd7f8f6922b812e72"
SRC_URI[sha256sum] = "7653d2b06298cf7f9242f33bc6a718cd65fdb7f6d4a207e8a36d94a866036b10"
