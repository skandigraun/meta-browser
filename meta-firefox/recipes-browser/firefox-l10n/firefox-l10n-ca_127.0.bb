# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "852292d8db59a4d6c99aa29739c2ad9e"
SRC_URI[sha256sum] = "a4931a839102050e80ae6d1da520110b3a06f5cd04ba574033d274bbc9838e5b"
