# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70128cbcd2e2d863e3a0aea2603bb3f2"
SRC_URI[sha256sum] = "628eccc12023f399f545d066c47527eb24041b371040f36c9af3fbf257792ba0"
