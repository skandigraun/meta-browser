# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8c989a052bc8155301d79fc63d4f413"
SRC_URI[sha256sum] = "c674e45c0e433136ed345c8348e7d643731dd1fa89d39161db89d79bb6719442"
