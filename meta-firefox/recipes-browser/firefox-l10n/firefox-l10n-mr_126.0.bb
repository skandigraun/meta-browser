# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2670c776a429f203a09fc5e913b165e"
SRC_URI[sha256sum] = "676d6104b17a22f072a9316f63a66361d7a1e72af601fcde7092d76601d3ffc0"
