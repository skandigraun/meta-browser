# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b243d71a0f702f7787b0acbfd0ce275b"
SRC_URI[sha256sum] = "0580f5340772fb599b76f3be24faddbd85108628b25cb9f9ce867fe4be7084d3"
