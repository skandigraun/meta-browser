# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "210ac5a455778a96b94727242bf80c13"
SRC_URI[sha256sum] = "ceb27e01dbd90c4c2099503977fb8b6ac7f7dae3a011daa4cd00be05ba3a68d0"
