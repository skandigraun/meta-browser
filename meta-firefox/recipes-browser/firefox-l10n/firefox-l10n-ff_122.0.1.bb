# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96c808e75fd50cd737023c96ea558670"
SRC_URI[sha256sum] = "0af6b9cbb8bf3afc9232eff42a6bb67167aa445883fd649210e8cf8b9a1a266a"
