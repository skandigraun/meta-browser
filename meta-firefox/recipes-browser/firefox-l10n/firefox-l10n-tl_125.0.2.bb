# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e4b5dbbc82f09342b0c9bb2ea861674"
SRC_URI[sha256sum] = "fc473b1731861475a624ce26d146ecf0b86b7218b5ed921b2aed066ede035f24"
