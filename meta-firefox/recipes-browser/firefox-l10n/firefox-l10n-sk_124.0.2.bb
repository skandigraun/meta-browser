# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4d0ceedcc578604f608b61ab2f5d7c3"
SRC_URI[sha256sum] = "4571f66cd824cccba489b7ba8e1e4f80da81bc61b54d533d84d4f135ece6e7ef"
