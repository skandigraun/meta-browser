# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f151331a98188c3a728fd7929e878549"
SRC_URI[sha256sum] = "4fcd2db7c0bf41d35bdf103d7d2d25c2ac9544fbdc70a2c7ddb8af13294976f7"
