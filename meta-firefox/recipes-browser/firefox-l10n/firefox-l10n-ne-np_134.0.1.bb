# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8888e0cc27e1ce3e3e5ed54b46386917"
SRC_URI[sha256sum] = "06f8eb2b5faefd00976e14fc17ffde6163258eeefd03792c1280e83b83920cb6"
