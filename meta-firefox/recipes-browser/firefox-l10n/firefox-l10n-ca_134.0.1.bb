# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf4aa2597c7ecf9ccf0f5481a7a15179"
SRC_URI[sha256sum] = "ea163e5cf74f6f6c901cbffea259620dd336471a0b0718c218c86d206190fc4f"
