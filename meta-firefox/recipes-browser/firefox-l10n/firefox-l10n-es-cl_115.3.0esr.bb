# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea269c267be662a495a8260fa6e56584"
SRC_URI[sha256sum] = "bb62e43cb86995ee9e7fe41cac9e126ca48c17b97070991630891753263779da"
