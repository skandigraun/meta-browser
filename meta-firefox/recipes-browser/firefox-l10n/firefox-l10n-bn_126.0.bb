# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c999076fc45ae1b1a746cdd4b1f156c4"
SRC_URI[sha256sum] = "2d5b66f98a6a9afd96c6a8a6a2a5a472f26a6efb9c5216e3d20ce32c5ddc813a"
