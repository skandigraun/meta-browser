# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19c5949aa6407ac176600b55be5e8f9f"
SRC_URI[sha256sum] = "0964514b4d04d6e09929881d93b598c6e12f65fcac3dc17a1f957e2c6730e739"
