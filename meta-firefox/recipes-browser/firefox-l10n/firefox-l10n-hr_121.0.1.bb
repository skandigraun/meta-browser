# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbaebf76a13aef59ca0ff68bd561ae23"
SRC_URI[sha256sum] = "232640120008200500cd0ec425e4ed5a557ff627cf66fc9ed7fb4eb96b414125"
