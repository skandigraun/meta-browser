# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8403e89d32fdb6dcd0a42479bc96bad2"
SRC_URI[sha256sum] = "914f64252d40298f4f075da9c1e3247e7085526787dbc94947c6879714854325"
