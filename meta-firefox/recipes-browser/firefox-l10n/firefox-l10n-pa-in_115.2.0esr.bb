# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8872ad1e6f9933fb3e8fe994e72d5ac"
SRC_URI[sha256sum] = "5182c53487e76d5e58be697aa4e06f7d81e9ad607177aee5e2cd51f141269057"
