# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8426a78ca15811c08bf96676f5f70d5c"
SRC_URI[sha256sum] = "ee21342fd11e06d87e584fcc68a718b4551e019a9b2ca09835c359a2cfdfddd4"
