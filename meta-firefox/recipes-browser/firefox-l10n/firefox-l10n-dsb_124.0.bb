# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "967e036918418bab19a2867b4500172c"
SRC_URI[sha256sum] = "c71d1b410d8003c46a405277917fe5c145405bfc593d3cdaa8b226bb12c1033d"
