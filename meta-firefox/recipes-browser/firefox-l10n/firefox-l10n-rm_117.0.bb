# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7f9216c1ca1e7914dfab7b81ed11c9a"
SRC_URI[sha256sum] = "25e2f579724168964554ddfdfbb695a3f2d8ea8d24bab6ca3054deb3b4f1ddea"
