# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a555faf2193efa90bf3751aa32865db1"
SRC_URI[sha256sum] = "edfda5f481b43f936c47d73e0f6daba7c3368d8e030d79eaef728f28d86f1569"
