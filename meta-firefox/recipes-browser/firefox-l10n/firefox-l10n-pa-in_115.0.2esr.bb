# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5014ccc92b86bfae7b0103421547afa3"
SRC_URI[sha256sum] = "ea4698e2715bc9ccb3872ace85706b9e9c61431261fdd64dd277996c2ed8887f"
