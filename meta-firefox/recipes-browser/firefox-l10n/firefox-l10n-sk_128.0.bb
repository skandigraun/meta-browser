# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f439f51fa05db206bbe2276f4347d93"
SRC_URI[sha256sum] = "fa28052ed8a5a6cf3be2fb909e9376e9512a5af96b684de9a886d674e5e3413a"
