# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "231f79d40722a9f87af8c953a54915bb"
SRC_URI[sha256sum] = "b0c370dce2572a773cf1d31c396151473b869d6a630733be8e9054627866f2b2"
