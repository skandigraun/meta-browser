# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89f9bfd6b62d10cafcae1c81c4246ab"
SRC_URI[sha256sum] = "f325bcde1455b5052a25bddfa9a41999f894848e6ba19aac4705901838b2a52b"
