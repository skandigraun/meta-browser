# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39a33117c5b576aa301b3bfff94346b2"
SRC_URI[sha256sum] = "e37a9777f844501898f2f82245f7254d88f56bfa560f8546acc29768cb8973d8"
