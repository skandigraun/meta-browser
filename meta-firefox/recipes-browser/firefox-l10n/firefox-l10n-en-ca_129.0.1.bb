# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93ffb7f2fb6bcf5fed5d8cacf83e94f6"
SRC_URI[sha256sum] = "518c90cc1e2452f14da5d1a64254f39dbb2aed17e4ea80c83d69a8624f5f1d9b"
