# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f6b68cf93f3d447cab004e7ddca0aac"
SRC_URI[sha256sum] = "f9c9703f64ed4923289e704584895f67c5e4a1eff41471d9888d4c9fc658f37e"
