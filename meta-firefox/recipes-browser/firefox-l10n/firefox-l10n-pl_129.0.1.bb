# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e34597d30d816f702051a7d87f48a39"
SRC_URI[sha256sum] = "07393ce116f5473faac344dc770505ff50deadafefe69282e77f33ae7471f3fc"
