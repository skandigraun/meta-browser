# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "853ecaa41ca8a881c32bdbcea3c6eb27"
SRC_URI[sha256sum] = "dc6753545bf1d899eba9a7b020bec10627190959bdd775269ccc0724913f67ee"
