# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "815ee17b33e937beac86a570da870415"
SRC_URI[sha256sum] = "8793c6c39f8e3504753d2c5da2a689d2880a3c9e42ddcfb567567383273935ab"
