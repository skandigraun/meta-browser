# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ecb2d3a0ff68bf01e39ea20b5f24965d"
SRC_URI[sha256sum] = "fbb3ab158c84aadbc6ea35c39c81f9cef7a37ddb392aa4e213d1b3be6c8d41b7"
