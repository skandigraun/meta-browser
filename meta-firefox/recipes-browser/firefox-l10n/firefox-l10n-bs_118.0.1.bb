# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84ff4d23722cdafc39984384193a9e12"
SRC_URI[sha256sum] = "c9c6c6e9be742eb2e65bae76f60a33242e34bb1fc81932fcd5cf5ef2c3dd8ca5"
