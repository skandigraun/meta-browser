# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51006251cb629a9b640c0df00a7a6ba6"
SRC_URI[sha256sum] = "e1d47d02c0427e2e4dfe5a1da2a1280bbd71ee946588da7f8ac7c3ed2914dfb5"
