# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d389b07151d1e834dc499b7468f8473"
SRC_URI[sha256sum] = "f54d1d2fdce269b8cbdddc3f1ca5633275aa621ab7a66f69e2f075162e3b1e4f"
