# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00e23809247e3ad4181d5d2238d1a947"
SRC_URI[sha256sum] = "918276c36d17a303a2dd30bf34e3cd5f8ddeb6ea5aecf57a318dfc95a4b00596"
