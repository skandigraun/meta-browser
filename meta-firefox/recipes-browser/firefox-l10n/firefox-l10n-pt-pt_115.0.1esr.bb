# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93e186ee90ffbe5579735d9ed7fabc05"
SRC_URI[sha256sum] = "8f42364ca91281e85380bda60cedd7e31052ba1109fd90e666c0a061f187f540"
