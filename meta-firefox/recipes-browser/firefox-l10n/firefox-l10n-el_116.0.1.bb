# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8320f39300ac906d16ef2940f8b94a4b"
SRC_URI[sha256sum] = "8769e000d93e0c793ddb43cec0d1653aed8abc1d44fb161d54859c07aec0b221"
