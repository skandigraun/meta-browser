# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85d664257ebc84c5444ab427ddd552a9"
SRC_URI[sha256sum] = "b989187f2e96e36876118a3b32da190b27d7b3acb367706c13570f97fe939692"
