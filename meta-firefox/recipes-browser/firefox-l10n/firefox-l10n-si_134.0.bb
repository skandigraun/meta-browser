# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c86859c49b2c0eac65546d8c705c89b"
SRC_URI[sha256sum] = "b439d9dfea67964606290a8013c62c90d7628c536477a6001966a5d5179786da"
