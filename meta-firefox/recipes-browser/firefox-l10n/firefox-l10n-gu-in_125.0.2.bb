# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea4cf75f4c7d4be75a09eb0c07cedc1e"
SRC_URI[sha256sum] = "6e973e61dc3326b55edb38184b95f04d480daa26c96a5c15c2d32fcf4bcf4cc8"
