# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8d267640dce207642bcffe87261d114"
SRC_URI[sha256sum] = "c79383faead35f01c237e600433e85c84cd2749353b0d2a0e8ea0eef284c1b41"
