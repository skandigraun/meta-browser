# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11d7f5758d84b7ec8ac18d38d0dcb12d"
SRC_URI[sha256sum] = "bc481e7edad2e5d9c8efdfa758a8a19e2b3e70172f58e87cacbd9209014710aa"
