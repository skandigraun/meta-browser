# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "046b13ad14758a2201d96ade477abe3d"
SRC_URI[sha256sum] = "27468edb73c6361f816a6581fa8491baf3382c6483d641a1f28913e2faaabe7d"
