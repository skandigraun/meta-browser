# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f944958714aa169aac774162b6b01756"
SRC_URI[sha256sum] = "129da129d82e962ab4fe50adcad0487ca1f516df9d9153557ee4722de9133bc1"
