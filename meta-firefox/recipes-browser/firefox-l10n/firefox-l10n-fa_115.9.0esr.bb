# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1317ed4b99dfbf15190c7a4ee37d430e"
SRC_URI[sha256sum] = "2abbce8912dfde69a88559b3ef027c919146958add598bd8d17281c0d7052e50"
