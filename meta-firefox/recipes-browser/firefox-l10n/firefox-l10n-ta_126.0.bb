# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "556083178eb45a359d5c91376045db19"
SRC_URI[sha256sum] = "565a742c9ce4a78a7c57394ccfe60179c632ff98e8dc5b67a634596919ac9fdb"
