# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2ceed7cdf0577b7f46f9f989854d269"
SRC_URI[sha256sum] = "5da4d200359a3faeb084c3b7c18bfd7978700dbe8b3b6c73db78040938d5dc7b"
