# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0682df75b00b7450ab0ca2e40566b8ae"
SRC_URI[sha256sum] = "69d2d513c012c6738d470b712169c821db1410bef5a8b19c503d630bec996a0f"
