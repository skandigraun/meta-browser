# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18a33cf3fda4a10fef228b71bea1649a"
SRC_URI[sha256sum] = "0d6feef555ba148bd24ed1e92f268ef857929b7d1507f7cd6e120e4d47d189df"
