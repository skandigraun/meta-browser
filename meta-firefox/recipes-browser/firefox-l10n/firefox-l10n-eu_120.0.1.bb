# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aaf5f28a8e278591631fbfce5ff6fcc"
SRC_URI[sha256sum] = "cb466e0b2e9b598df257c8378bbcfa993c4b3e7dee74a83916c7c144587ba31c"
