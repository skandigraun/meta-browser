# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95f98c329f5b7895b6c54e797d0809f2"
SRC_URI[sha256sum] = "71f6b7879ddaa703906241fcdfb128ba5757b604f4a5fd0bab53c2d0507a6f76"
