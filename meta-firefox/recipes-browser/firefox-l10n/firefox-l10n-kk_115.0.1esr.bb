# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee6926cce81aca35aa4d7990311920b1"
SRC_URI[sha256sum] = "650fd3a419974a21c83e18d5e2e94656ff7fc352d7922a52b26ca4b3203f5861"
