# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3f6c5308c807b55e97f08fd3e02baaa"
SRC_URI[sha256sum] = "c46e7646a05ee5428bc07852001eeca42ae41b8ff08c18cef2938a7cdaded0cf"
