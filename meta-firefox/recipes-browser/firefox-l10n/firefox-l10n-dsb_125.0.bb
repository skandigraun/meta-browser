# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf0de545d7133d1f6fafd65e4eb55a6f"
SRC_URI[sha256sum] = "ebd548d9af22b9e8969bc45120042561f2f6e521d608c15019beaa6c18a11887"
