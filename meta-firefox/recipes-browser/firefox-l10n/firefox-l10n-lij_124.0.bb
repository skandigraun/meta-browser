# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7e488906960138c4df45d65041cf0f6"
SRC_URI[sha256sum] = "575880cc0c8d4589f0d4a1f4244d1b6be12c5a4c934860a76d2c5c0865299e76"
