# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47b7b9d637db97c642c88fe1217d3410"
SRC_URI[sha256sum] = "0b9311188e04083847bd5c702618b60f42844df22b76b4671216b5a9fbb13d03"
