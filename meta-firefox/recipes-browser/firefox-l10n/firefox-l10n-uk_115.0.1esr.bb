# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6e32643bd01b542ace1fa3050ff05ac"
SRC_URI[sha256sum] = "fcc148022eecfaf7f0eb31fe86545edfffd81154cb6db79a8ed1a7d5305357fa"
