# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5533b3e7c0bd4f1b4c3eeee5248fa51"
SRC_URI[sha256sum] = "83ad69bc18ea4f9fcf7b10eee5f805b7a970853155206c6ca5f95727b4fcb08f"
