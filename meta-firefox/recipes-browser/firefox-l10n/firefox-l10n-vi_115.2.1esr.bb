# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd20e1d8af1101ed9c7bb89bcd940a53"
SRC_URI[sha256sum] = "02caf13adbb860432a07ff402ff02255b81384a679a7fc50ff12ae2ab8328294"
