# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a206e8ea7c54d5cfc25c0da4d356817f"
SRC_URI[sha256sum] = "a92d2281181966308c7f72ca7599bdd4c650bbb49113d40fdd0b87891525f695"
