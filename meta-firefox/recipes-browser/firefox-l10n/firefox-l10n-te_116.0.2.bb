# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "513e74ac1742cb4b4f88037068d4f692"
SRC_URI[sha256sum] = "ee37a26f0aa0d4b9ade59f7f033ba3068ea5aadbc8662a6005e7b256cd1e40ac"
