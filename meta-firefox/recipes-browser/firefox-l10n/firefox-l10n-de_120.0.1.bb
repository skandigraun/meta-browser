# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c17cefa8a84627db0dce43640a899e83"
SRC_URI[sha256sum] = "b489a98d80e7c36ce04a8e8b7b97ff731353f9ad66b9127b2feaadf534cc24f5"
