# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d8b87e0d8b8be3ddd2781d24c1c253"
SRC_URI[sha256sum] = "a96a646ea44e7b2763ba258b1a0b651c6ac0d1a587d2340179482af2cda9e1cf"
