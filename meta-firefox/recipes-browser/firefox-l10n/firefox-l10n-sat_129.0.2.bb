# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07cb0f47f53e3b70a53a169692bd074e"
SRC_URI[sha256sum] = "5b925176406f8389010eb8c5fd9457a4733fad4da5467d554fee962bf54192c1"
