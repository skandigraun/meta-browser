# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "151c02a90b04577106860c886043eb64"
SRC_URI[sha256sum] = "ce0fada33b655913ec4f23d7e6894c4be430e0f025d928adf0144cc1f1c87aa4"
