# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43dd23a0cf7ecddc8c092711e9e9b45b"
SRC_URI[sha256sum] = "eaba9d61657cd02c4984c72253953f12c97c0d0ac5e760b9e63a16bce0b310cb"
