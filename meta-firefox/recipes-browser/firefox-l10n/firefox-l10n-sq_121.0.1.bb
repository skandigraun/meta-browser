# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d9bc8513a46dbed37ae955d54a57a71"
SRC_URI[sha256sum] = "5b294923c6e1212b0c07e7212f47fbc9d746e0841ddac1d1558ca71661fb3023"
