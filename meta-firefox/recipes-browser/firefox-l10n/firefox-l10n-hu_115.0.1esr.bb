# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fec4bc15551b96f9d5a21697e64c514a"
SRC_URI[sha256sum] = "40debd62b32aef2de2cd61e83ba22028d1b326101b187b4fa426bae4bc63f9c4"
