# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a7410a60026cddbe372753c2743b4ad"
SRC_URI[sha256sum] = "016b8a5a2fabb54d9e712c95580efc98b6d428048ce94c9453eba0fa51bdf67e"
