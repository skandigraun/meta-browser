# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "42bde27511bbef13e2b23be040795ddc"
SRC_URI[sha256sum] = "5d537ab712b0a0d959dfdc7340de8b4c1ae71af1a87145ef2073a38b6f0142f2"
