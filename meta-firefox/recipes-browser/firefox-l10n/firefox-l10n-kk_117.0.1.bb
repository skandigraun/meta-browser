# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5da03c8c6ae95f239e223476d97edfaa"
SRC_URI[sha256sum] = "bba9041a1a7d6a936fa2935663112a5fc1f60bf4ca02add9b4277d4414e8f1a1"
