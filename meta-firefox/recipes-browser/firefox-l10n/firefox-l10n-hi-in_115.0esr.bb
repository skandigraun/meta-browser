# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bbad9fee79adffa355ccfa5a9b4075f"
SRC_URI[sha256sum] = "a27a3d3e5d7c932464e3b24bed51405217753f1eec97ffe26e77f58dc5fd90b5"
