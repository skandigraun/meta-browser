# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef2fc18ac045f3ae6bdc0762a8edc54d"
SRC_URI[sha256sum] = "f7f0eaad3f99110be1875ac59e2ecb02a1fd02091a355e5368e01561dea73c9b"
