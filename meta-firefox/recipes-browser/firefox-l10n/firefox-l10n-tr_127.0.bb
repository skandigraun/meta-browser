# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9933921d6bc8bf150a168ba15d2685f5"
SRC_URI[sha256sum] = "217a39887b2a6674cd7ab71eec041a4e1ffadc9ea7968809e354161d0b42aa5a"
