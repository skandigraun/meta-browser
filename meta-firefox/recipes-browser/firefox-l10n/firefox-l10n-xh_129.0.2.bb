# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2350ad4426492e71334280538ad2f46"
SRC_URI[sha256sum] = "781aed2f55cac06613c07151fd6fdaf162eebcf567ec20d58fb77eb340221bf6"
