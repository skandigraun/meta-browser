# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "971a9540067b25318684f371e60549ac"
SRC_URI[sha256sum] = "605be9b724e54c688c5656ccd0c5bff8e740298129381241b63f899fcef99983"
