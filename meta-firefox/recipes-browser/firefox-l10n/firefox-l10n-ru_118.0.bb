# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3950b06d0fecf7dc8e6430384f13e6c1"
SRC_URI[sha256sum] = "803895097aa58d48982a2cef523189d776116a52c238a77949bd2f0dc03d2ae7"
