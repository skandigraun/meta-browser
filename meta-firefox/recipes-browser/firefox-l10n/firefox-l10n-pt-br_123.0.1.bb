# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "238ce132dfa5bd9effa2aa8957ba36c6"
SRC_URI[sha256sum] = "344d27240dec42cc5213f417c05f44881b4e8a7304e4d65d39b4e9c128dede24"
