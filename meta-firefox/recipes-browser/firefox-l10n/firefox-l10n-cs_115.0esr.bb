# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41e8d53da17990a5ffd0cd00080a9a4b"
SRC_URI[sha256sum] = "f9cdedcbefa0a876cefae9d52b372dd4308e81692991487c0bb9f1dea6f8aa94"
