# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0d242fb54d28c45350f4d0c89cf205c"
SRC_URI[sha256sum] = "1ca61d01db1f752bb843e18a8d5f15a45fd6d528b44046ae276e025c1c272578"
