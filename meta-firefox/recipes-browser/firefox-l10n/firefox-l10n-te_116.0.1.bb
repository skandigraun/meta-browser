# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0da9a9b5cd687a94183ea970e8184c71"
SRC_URI[sha256sum] = "4fe638cea6d0453e40906780e46c26f779c3d46639269d1f91cce29f2c99cba7"
