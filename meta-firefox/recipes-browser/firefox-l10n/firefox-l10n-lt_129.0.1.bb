# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113545812b891c40681439d2b110368d"
SRC_URI[sha256sum] = "09c9b37e72d22f5478f7184521095e57d36cb3598c97ed7dc8bb2459f17c3773"
