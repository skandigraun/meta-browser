# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "724b9f1df64e2e0fc0a6e3fc1316e034"
SRC_URI[sha256sum] = "3ad23f912c12b62d245fe43f077919becf2d5d18bcb4c08320690aaf33006ee0"
