# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0f86b11dcc0553e5fc0b186aada2331"
SRC_URI[sha256sum] = "d4550f6f4326a11c3cb7d61488edacf140e90509c7dae2182a0d06a96573285b"
