# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d20f0a6473728d60becce7296c9ea09"
SRC_URI[sha256sum] = "345b1e1264a22dc87afffc6d6a292d1b96a3dfa46253febdbc06d8972127e974"
