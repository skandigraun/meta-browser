# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ec39eee976b122513ba7d6d6efcde28"
SRC_URI[sha256sum] = "26dbd78d4d5dab291a7ecb901160286e478bfdc9a1b6baec48aeb4556c86ba5f"
