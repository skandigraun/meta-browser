# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "094f78b490cd24d7f3653460bd09fe4c"
SRC_URI[sha256sum] = "880e0d6bfdd1d11218ff64167f7ef7ea1c25c1cb9358d2b4463aa138ce2c1566"
