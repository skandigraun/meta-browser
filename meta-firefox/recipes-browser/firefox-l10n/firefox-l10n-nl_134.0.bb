# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c829dc851a9a51e37c5182fa745ac8a2"
SRC_URI[sha256sum] = "79c73d210816dd6429c85e6339f17eecb8b0f6d52d8fd2af06b2a3c7f910e503"
