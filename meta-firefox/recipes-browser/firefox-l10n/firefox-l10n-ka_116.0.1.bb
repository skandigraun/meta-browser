# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b91e7873dfc45e6cd7926620ae797c1b"
SRC_URI[sha256sum] = "a9865cc3767a445fcb44f904a16b6bcc29a70e748cce185d3e30a6f7a23e672d"
