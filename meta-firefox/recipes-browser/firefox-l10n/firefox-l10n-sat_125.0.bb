# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7abd651c6bb8ef1e96ccb4316bedba0f"
SRC_URI[sha256sum] = "86826cce504629e9b9623393f0443ca8fe49de2d029a4cf5e23583ea13d44d90"
