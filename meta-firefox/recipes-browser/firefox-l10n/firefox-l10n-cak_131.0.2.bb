# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea66ec39cc9c36ca6f4e0e1d62f304a0"
SRC_URI[sha256sum] = "905701a3e646f3a5bc869474f7fdec9e0ffbc525efa1684bd2505647e96f6f81"
