# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dde98eb4f60c0bce13b3d1a43885351d"
SRC_URI[sha256sum] = "9bdb51e6c0891456d8774f2a9b8bd2f0968fd00c7821a40f9358d40cb4c89e31"
