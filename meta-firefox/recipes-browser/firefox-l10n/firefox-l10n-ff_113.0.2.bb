# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "821e4296859e2ea4bb19ee56456b5e1a"
SRC_URI[sha256sum] = "47b51eb41ec00bff234ad9e81638584a831fc46116baef8217d4f71a7eedf2d9"
