# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8f50d8119f05c351ef279fed8d9c188"
SRC_URI[sha256sum] = "d6000dbbf2ba02d22762464cb7858b276d47e69ce344fc7c92360ac42802ceaa"
