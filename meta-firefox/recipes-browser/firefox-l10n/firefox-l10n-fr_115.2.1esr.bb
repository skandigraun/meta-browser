# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d270201f3a5964b1e764aca6b046215"
SRC_URI[sha256sum] = "d0d2c92d0ceb38fe2f593c4804befa3474bf6fcaf7a69f4d04aa6d6dc73c4caf"
