# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff15f4a1a10532df4841ad46d56ef3d0"
SRC_URI[sha256sum] = "a76a999becbdd625ab6020eb539d2b27122a9edbb55e944b7a9383948264c13a"
