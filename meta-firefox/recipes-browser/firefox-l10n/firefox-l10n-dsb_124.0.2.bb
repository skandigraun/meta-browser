# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b5273220e7c4e3ce3e293e09fbc4813"
SRC_URI[sha256sum] = "6ef3edb27cdfc9adf1a1a58365f3e2b891289fdef742202e2202eb7953fecc41"
