# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e430be43a88b9304aa41f62b6e66279"
SRC_URI[sha256sum] = "af06730d3badc4ea8450b763458fda8077f7142f20125844c40e0068073b455e"
