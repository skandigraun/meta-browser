# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74f936946b758f5207d5aef028b52c23"
SRC_URI[sha256sum] = "753b6b2a093314f7b8027c5c01be0fb78de1878f548d10b3caf10163be89a937"
