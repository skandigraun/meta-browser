# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8a72d27cf1a1fa6ec5e78dc77ffacb"
SRC_URI[sha256sum] = "0d1ea97cf1cee6d5146ff716a5305f420bd3da8ab8d13c895cb96e4201d7c6c8"
