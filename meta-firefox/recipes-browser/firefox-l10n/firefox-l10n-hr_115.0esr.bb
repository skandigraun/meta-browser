# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3f31a2ca986872607ffba1a89f788f4"
SRC_URI[sha256sum] = "385e87b8d03669d4d44553e45dedfd635a1657d00a95f4418214c0d007569fae"
