# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47d5386c7634997de6d9d4473aeb1b6c"
SRC_URI[sha256sum] = "90955db84758ac122df44e7170ed363fc66118e34e9d87c44c9c40966b0463db"
