# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceda70d35d5af95b234e32ab9f513de9"
SRC_URI[sha256sum] = "2b373986cf1573352a1973beceb490130bf9580378c6e55f3e6e042f6148e71e"
