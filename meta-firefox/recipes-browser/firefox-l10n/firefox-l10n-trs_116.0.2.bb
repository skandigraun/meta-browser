# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9064b96d5f8cd7576bec84508859bef"
SRC_URI[sha256sum] = "c08767157f60bbae243f9d2d9964b4ead2947c16c184ddd7b3bc6613cb53c776"
