# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ce9eac0a427cb1765d3c1eb489b3ecc"
SRC_URI[sha256sum] = "472ecd15cd29c15c30132bc3c5e984fd09496832d02095e854b6f7153e9eee20"
