# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c459b6726d8eecd99e321d15c7ae9f54"
SRC_URI[sha256sum] = "d692b04e6fb7a23dcd448cb28633a6d2ae40862a624332ecaf4555a0db1844e9"
