# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7bb31775075055c5648243e19939e21"
SRC_URI[sha256sum] = "d363baa2a5cea0868b575d662890b333a88a89db499f22540fc6f900122fa557"
