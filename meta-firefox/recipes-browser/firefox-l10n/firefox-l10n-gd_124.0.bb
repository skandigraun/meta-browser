# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06eeaec07c6536356e6a4c26af6c5d98"
SRC_URI[sha256sum] = "e253fca46854569aa1d1c668a09829cfa934f04c43f78bf8fae9940f6e888e6b"
