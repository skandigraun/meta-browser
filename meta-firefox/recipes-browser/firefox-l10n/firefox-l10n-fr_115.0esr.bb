# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8300b8a4712859f546577f42bb28dbac"
SRC_URI[sha256sum] = "ccff3a218d42ba6ebf3c3b84f17b427fd3f60438016a184c9c882f248d8302c8"
