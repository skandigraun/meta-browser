# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30b89ca008579b0bd01badae7059b043"
SRC_URI[sha256sum] = "d9202eb90e41bafd5dbdead763a8e649cbee353663314100906fc5107a78f091"
