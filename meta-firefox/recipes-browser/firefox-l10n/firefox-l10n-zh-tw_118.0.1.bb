# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dd28b6858bdec059a829e1dfdadb3a8"
SRC_URI[sha256sum] = "9fe12dbf2f29ad0c5456cdf678a2cb22bbe458008cc42bbae8d90c12050c86bb"
