# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eabfdf405f6b2d1045197b44cd59069"
SRC_URI[sha256sum] = "7d72551d7ab3fe26685eb72735dc01b30d847c27d4d9fdf2914fd1251aa6d2f6"
