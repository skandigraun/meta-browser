# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8b84ce64dd7973a9c6dc1095c0e1f27"
SRC_URI[sha256sum] = "abdfbdd20f7994869b1ec393837b9b6480b9b1782c484100e81b2f5653957375"
