# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1fecb6d8fab41bf49463d3934295e62"
SRC_URI[sha256sum] = "715f17676c37c1e017e73439a375051b87cc623f8a52fddf7b5bcb8fd63c2579"
