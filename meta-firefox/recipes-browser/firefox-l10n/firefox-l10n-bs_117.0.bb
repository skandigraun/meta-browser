# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1404dabdda077d3ce5525399de659b8"
SRC_URI[sha256sum] = "2ce7d3f5ca0015568c5710a2fb33ad50aac0f2d5fff62080626b33e5be50df5c"
