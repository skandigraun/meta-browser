# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90b2ed90c2714acc67243d9d524b54ae"
SRC_URI[sha256sum] = "bd88505901ceac5b420f87e08c6e88e0a25279a3b77a732926c73547b13133e6"
