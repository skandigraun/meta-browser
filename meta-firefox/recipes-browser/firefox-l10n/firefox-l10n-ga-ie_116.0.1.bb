# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fd99599c473ae5a201e948af2b4ce75"
SRC_URI[sha256sum] = "045db8a3684a6d026260861f455a69e39c78ec8b2de158531600f7945b1a8e8d"
