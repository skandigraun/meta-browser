# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56b7d1d5b69264e5b9d7aac85e8de005"
SRC_URI[sha256sum] = "62befb2daefc6791cd5a5a66600b5e2b8216b32ea0cb8137a316ba0216fc58b6"
