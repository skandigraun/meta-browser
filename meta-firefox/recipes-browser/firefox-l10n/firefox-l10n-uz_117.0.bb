# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1aa824280fa48612f1bafe7473e59be"
SRC_URI[sha256sum] = "ceacaf769bf5734a8d127bfb30b845c2b19521eb4664b15e25708e29085a43cb"
