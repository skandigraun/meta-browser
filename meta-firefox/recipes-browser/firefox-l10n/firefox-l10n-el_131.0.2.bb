# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fe76d9f250d817efef6723a8a79a966"
SRC_URI[sha256sum] = "3b1a4d2d35248b4e840761b6de24cc53743632ba22fe5e66d9dabc8461b9dd57"
