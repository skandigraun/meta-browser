# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f2a4a33a79264294545948f82395ce5"
SRC_URI[sha256sum] = "5fde6b5cc3735fbfa5dfac1e87034a3cf08fc074a0bc25af6098b59dfe0b435e"
