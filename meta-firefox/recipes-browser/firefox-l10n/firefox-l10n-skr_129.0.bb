# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2987b8895e38c03e805c857235a64a7"
SRC_URI[sha256sum] = "d29585d5bce080576e65439e3b8e80f07f13672d7eefdbc022f0c7f08596d954"
