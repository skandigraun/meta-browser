# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ffda4937249bb05b2f1bab3aecebb4e"
SRC_URI[sha256sum] = "e181182c3b76a7659040af6f9c58836342e3bb106a46f987230f8012c40b0b90"
