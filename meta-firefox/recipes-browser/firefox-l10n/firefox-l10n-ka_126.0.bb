# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81a2d1af088b34610b0b03c36fadf483"
SRC_URI[sha256sum] = "1e0868261e1bfba0a53ac28f011f813475d5d817b9cee49a5d1638c9a69fb060"
