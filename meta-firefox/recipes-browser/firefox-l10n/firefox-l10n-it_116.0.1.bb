# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc2fbbb8dd01bbddc47099883e8a5068"
SRC_URI[sha256sum] = "8af77c47d7b616192d051729b45196d35afad8f92d8565aad5fe32667af1d025"
