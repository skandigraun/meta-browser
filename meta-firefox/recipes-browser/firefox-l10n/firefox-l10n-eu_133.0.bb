# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edde8e04f657d7ee882b073f0fae27e9"
SRC_URI[sha256sum] = "0202ce469fc7f5259d637cdffb634577203511e4772f1772515a3d88345cbaed"
