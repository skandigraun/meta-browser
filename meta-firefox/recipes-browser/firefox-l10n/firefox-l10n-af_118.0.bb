# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "704afe3ab8be4a23cbc3d1b1c751d7de"
SRC_URI[sha256sum] = "aa7cbfced2446de34b8f2ad009d46f3b126749cae8c093bb7e0e913547b098db"
