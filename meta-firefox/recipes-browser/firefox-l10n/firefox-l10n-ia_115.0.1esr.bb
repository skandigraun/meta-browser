# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "771c02483ca8f0d475d994f14d904200"
SRC_URI[sha256sum] = "93cb54cb10f6feffd3addb70cd064b4be96d8e2268e72f31d98390097aaa9991"
