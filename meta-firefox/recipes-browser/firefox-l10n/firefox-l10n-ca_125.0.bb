# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adc51709b9190898c5af895448ebf545"
SRC_URI[sha256sum] = "35b1c7958e667596c51ffd5ddcab3b9b113c8f784983bebfbb8197dfe83ecc35"
