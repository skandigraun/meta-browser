# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18a3bebcfd7376fd814529b7872beef7"
SRC_URI[sha256sum] = "a1c7e0419b041ed03b2dded0e737f654f5db16995fa95d3d0aed56e005ba3157"
