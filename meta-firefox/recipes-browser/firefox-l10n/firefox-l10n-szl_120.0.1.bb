# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da6f2c670315644e2fc967e5aebe1739"
SRC_URI[sha256sum] = "d2481f53c638fd2d9cab5b90ccac9010b50395c5d8c33fd60f7462c72f8e3544"
