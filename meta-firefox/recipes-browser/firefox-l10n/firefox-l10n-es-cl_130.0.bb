# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d44397550c4ec0c097f3787e3e925b09"
SRC_URI[sha256sum] = "bfb5b11ff945ed6c78d28b59482e759ee3c12348ba1828aa1b6ce1677df9b42e"
