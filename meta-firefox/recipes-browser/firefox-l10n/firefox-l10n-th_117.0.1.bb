# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b81029f19b44882a935d20fa7731b4d3"
SRC_URI[sha256sum] = "9ee6e65e79fb17c0ff977fe3da8109e4712c255480aa161029583f8b3cab345d"
