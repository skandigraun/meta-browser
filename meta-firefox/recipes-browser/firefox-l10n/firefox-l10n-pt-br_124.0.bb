# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "044f5303f457739eae3014c8dcf86d02"
SRC_URI[sha256sum] = "8e2377c228895c671d225ca7d162af6e39978c83fcdef4da8efffe2e7efbb59a"
