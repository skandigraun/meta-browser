# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a75bf71b60635a8e6d753b9d90187c96"
SRC_URI[sha256sum] = "07acba0ff5d4a0b1e529680eab33023597fd67aa0cd44f3ca335571fd5ea717b"
