# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8953761409f9ac4dfcee8fb8d4dcb34e"
SRC_URI[sha256sum] = "a755066c4d14fb5a08364cec06341e245e1602f4d368c679cd7d0e78e73eec55"
