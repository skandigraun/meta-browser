# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef9fdcd3707a05601a304060c008e881"
SRC_URI[sha256sum] = "54565212337c532ff2d0d3cfa23f58b953ef2b9ad7ecff215e4ef69a9923d4c0"
