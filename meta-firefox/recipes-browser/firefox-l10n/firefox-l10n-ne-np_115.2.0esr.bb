# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5de08d5bf82b1c4279b9834952e867a4"
SRC_URI[sha256sum] = "9a6d6c0767cbd8ac7918e9acf1fce822e8f08d228fba336af10aaafe04ecce98"
