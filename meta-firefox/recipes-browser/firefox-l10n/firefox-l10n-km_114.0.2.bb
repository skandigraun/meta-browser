# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c658239606d78dc67feb0bd396136967"
SRC_URI[sha256sum] = "d61bf94810660ef25cf892fb2f8dcc5f75ed0d065352c6835ea078bf36e05cb4"
