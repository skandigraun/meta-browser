# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "712bf49421a0a844eb3eb9d306961ea6"
SRC_URI[sha256sum] = "4e6d1a184a1c906d5f954c422cc4ff43e90dfca9420dac02e9707f58fb582ad6"
