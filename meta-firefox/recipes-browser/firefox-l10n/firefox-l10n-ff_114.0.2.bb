# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cef621df6e19a2c8c2b0de967cf9747"
SRC_URI[sha256sum] = "a49c6544fd8b6c63597b4863d5b1cd62e18abc79b4051235a3bf23737b9d2d66"
