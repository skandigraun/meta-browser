# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fccfc682ac8219e2a2b248c1593cb07"
SRC_URI[sha256sum] = "78823257b494e816734af4a15306a6fda3587d75187528642801e74ee94cb3dd"
