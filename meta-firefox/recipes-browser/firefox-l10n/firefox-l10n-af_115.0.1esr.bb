# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd38369ac596dd0f9f18e36818f6b997"
SRC_URI[sha256sum] = "dac4f61f5b09f9cedf6342d9c6f3dd25af9d03a07707f6b11e62c99dc9e784b4"
