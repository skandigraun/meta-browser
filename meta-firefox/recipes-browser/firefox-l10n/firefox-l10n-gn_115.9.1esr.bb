# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb0d9878c441a32de430c024fd835e40"
SRC_URI[sha256sum] = "5e20e74233a622362e4b0a2fcca11f25cc0b158407fa3424f82654a8ced7508a"
