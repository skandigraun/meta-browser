# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fbd7cd02561d18c6d4034e2dbe4d763"
SRC_URI[sha256sum] = "e7ef638bc62b42b7839f20613a08f45ee066c46dfb9bd09d4b71eccecebc6906"
