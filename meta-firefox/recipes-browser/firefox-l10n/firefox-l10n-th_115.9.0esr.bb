# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fee944de281286759e350877100cb71"
SRC_URI[sha256sum] = "b20dc0e85e6cd1bb3c508f3b3faa5ec494ed34966eb59ad31d6b09fd4036d3a4"
