# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03a26a785e1eb4d101f544d9c6ca036f"
SRC_URI[sha256sum] = "613406c55f2f8a5642844f28b2eb9932269592e58732550d156a608a7b3b5dab"
