# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a589129a1172627ca373a1d194cbd158"
SRC_URI[sha256sum] = "cc3bd059a687377cf683454dbf60715fd596e23125624f1a9a48dcbe6fc8108d"
