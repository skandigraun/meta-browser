# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0e8732c66d7d1d9cfee931eacad43c2"
SRC_URI[sha256sum] = "f529b1c6763fbfdd42102917b4c45d720447ba01c7e82ca24b93838cc22a4ae5"
