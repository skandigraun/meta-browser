# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d597af7e73b08271e2d2cda3f440cd05"
SRC_URI[sha256sum] = "1a36f2eb980fbd0668e64f15f8292a23977be9aabc90067916845ae7a9196451"
