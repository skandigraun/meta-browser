# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63b86d05d8ec47fc9ef0c2af751d87dd"
SRC_URI[sha256sum] = "00e9c1da89a92234264aec093b5939a105bb766caa73a6c30b81dd8bfe0499a7"
