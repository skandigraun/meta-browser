# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5107aba26636b496bb66244d4ffe0c9"
SRC_URI[sha256sum] = "2be12d0865d629031d9d698ebf1139ae0ab0ee4de822efa306afaceff34d94b6"
