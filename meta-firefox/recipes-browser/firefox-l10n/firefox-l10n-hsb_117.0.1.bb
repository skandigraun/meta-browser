# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cdf609c2e62c6c03530327f052396bd"
SRC_URI[sha256sum] = "28fb805e99ad5daabd934e5e01ea4f0f56af2b1dcd3b8e13c39d12f3d940af91"
