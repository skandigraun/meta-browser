# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "627f81620c7680726c779580e4b0e43c"
SRC_URI[sha256sum] = "e3c5e95e4851d6af3546b3500d5ead11ab6b2d54925fa0f9c65a500a82963eaa"
