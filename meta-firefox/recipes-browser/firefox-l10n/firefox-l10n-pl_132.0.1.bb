# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6af4b12f78dcc178124ea26889264fd"
SRC_URI[sha256sum] = "ccda3b0fdfc0b60d63e46f1924d2b9aaad338b08929ecef4154c96d3a2d579b1"
