# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56d8fa662dc3912bb82f62886105dda2"
SRC_URI[sha256sum] = "098cd620fd0808c58bd07ae6947d063a2a4896668b9514897928084cdec9efb8"
