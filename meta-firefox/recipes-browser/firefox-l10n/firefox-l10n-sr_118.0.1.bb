# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9804af3c0b2528e1f54eff0d4c569290"
SRC_URI[sha256sum] = "0645537ef25a8ea9e398735b3c1bc1f144b0a20210665bc25ba5ae738cad8972"
