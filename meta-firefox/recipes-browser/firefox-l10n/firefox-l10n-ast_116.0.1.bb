# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ff5a5212be186a0aad6c534c674f73e"
SRC_URI[sha256sum] = "8d3628b089d801a6bc41a56af8b0645b9593a9b8020b78bd06d1eb53d6395453"
