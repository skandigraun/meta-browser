# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c6be9fb122cccccb5092aaa6273855d"
SRC_URI[sha256sum] = "85a57d3d4746f6e43c3f24ca9d7c2d873ba48166772c0a127485381b4017d9d2"
