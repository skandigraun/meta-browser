# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91c7ada597674a0c98feceaa4b20f0b5"
SRC_URI[sha256sum] = "95e685f79cf04c6cad487c056f8806e2d4ecd95716d48313c4218ad25d419d37"
