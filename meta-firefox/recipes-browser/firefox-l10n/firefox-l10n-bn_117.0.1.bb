# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a2dcf0439d975635808892f501ed5b9"
SRC_URI[sha256sum] = "c786e80e8dd1a0970ef6ca2eb88d5f2a505e3da17c0f1eb5ed5f55bd5f73c9a2"
