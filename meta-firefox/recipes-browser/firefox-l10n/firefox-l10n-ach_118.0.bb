# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3347f9bf5804a22d6d7a0dce32c48bcf"
SRC_URI[sha256sum] = "7c2a16be7c38b995aa6f1d43cf1d88bd44469355b98937ad442534bd091d3099"
