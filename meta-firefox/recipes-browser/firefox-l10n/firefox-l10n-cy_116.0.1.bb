# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68c0ed26212a18d28dcebec82f9162c"
SRC_URI[sha256sum] = "830c77d85717a11c31fce8998c77b144c837f66ec5ed6d065be38ea4d7281327"
