# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46d48d762d38cad294a60d8c7ab8fa28"
SRC_URI[sha256sum] = "1ee6f9a43020c29cbfb8bdc8769a284c69289968b51907326eef21cff691695a"
