# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a339cf89dbce726b4b509435596e979c"
SRC_URI[sha256sum] = "7a5de153c4cb458be8a2edc4352f4af1b2a026c1032d733b1a0f1975b1fc900c"
