# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bc649b0e4adfabab932e43763de8d9b"
SRC_URI[sha256sum] = "70247c9ee579b958a69618fd0064431396d6b99d9c6b3a9f14a25556111e60ee"
