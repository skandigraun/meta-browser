# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a2d6a2d88441b46ff99641834a6be07"
SRC_URI[sha256sum] = "18e9e08f903867623756233d82e4f6ff757f744961e4a01e554c016babe24e97"
