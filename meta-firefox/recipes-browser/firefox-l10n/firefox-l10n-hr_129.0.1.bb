# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a4045eaad94842939a8c1e642d7996e"
SRC_URI[sha256sum] = "6ffd26fda9f1f8197d208afb1682566ab4aea25fba8da80a5b0b5c77a1932d2a"
