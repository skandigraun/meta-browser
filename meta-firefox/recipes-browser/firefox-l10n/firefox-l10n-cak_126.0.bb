# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35fa709c84830ea30ff0a40b6ed89920"
SRC_URI[sha256sum] = "3982299cff904d4935bc9b79ad172ce4887475559ed30bcf2a93376e168c62e7"
