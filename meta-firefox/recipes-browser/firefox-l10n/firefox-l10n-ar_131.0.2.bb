# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e7c5d2e7b4756adf4a3be38b684b94a"
SRC_URI[sha256sum] = "da89f667be2a5a1e6c161b91a43fa3d169b7eb53631b999ff663a16ad53f3364"
