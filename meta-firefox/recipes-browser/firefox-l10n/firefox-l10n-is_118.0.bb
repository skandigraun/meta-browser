# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e1a5ebbfa05174d2c1ef1c9b0b80a4d"
SRC_URI[sha256sum] = "8b2b1c7c1998fe76efc1f4cf759908d3d280fc1c033515432eae1b9b964b6134"
