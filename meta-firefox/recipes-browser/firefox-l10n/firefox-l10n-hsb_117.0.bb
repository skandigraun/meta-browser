# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "814643ab709c952533d837c4665d1397"
SRC_URI[sha256sum] = "81af37dc12b664e48149dac23da492a296b222068e4987fd7a5a229d91389360"
