# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55b9160d27e678aa05e81d409e6c7675"
SRC_URI[sha256sum] = "ca5bd7f6784a59846476b4c04d292b8cdd5a9787c81b18388f14ce775e321da3"
