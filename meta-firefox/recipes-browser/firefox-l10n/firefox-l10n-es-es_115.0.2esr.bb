# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bf766f5f84388f21b1cc3439c505c42"
SRC_URI[sha256sum] = "1fb5f0898717004f704693a206dd716fd42bc887017103745e572c1d39f77810"
