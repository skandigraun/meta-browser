# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec121010e110b52c7db33cc8bc3606bd"
SRC_URI[sha256sum] = "06329eebe57f4687dae8beb0803fcecf1f6274437427dd04f532ae377317b598"
