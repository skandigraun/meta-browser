# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0138c6f34ad6aa38bdd73f75d28c30f4"
SRC_URI[sha256sum] = "017643d9c3b9007811cdc071030eef4c1beacac525ae0e1c9a132633c745cb15"
