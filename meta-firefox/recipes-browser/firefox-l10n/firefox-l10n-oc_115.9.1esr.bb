# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38abb5a91f43af535a9f747d44adb8bf"
SRC_URI[sha256sum] = "8cbdd3e2311359b69810ed8eb131fd62b08b837619f738a6bd7652eb6e86460a"
