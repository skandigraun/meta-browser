# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a52069a9b7bed6d355f21057005710b2"
SRC_URI[sha256sum] = "2500eed0ab0ced430dcae03c8acc846ff32a188769a9d5df5d14cb7172214a5a"
