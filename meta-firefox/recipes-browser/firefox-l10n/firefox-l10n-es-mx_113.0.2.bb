# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bdd20a55872d299549900bf42b5ee19"
SRC_URI[sha256sum] = "06d88b0f471bd56719c378629366fa9ef94c51b0e4ec6f10f41b512af813887d"
