# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "825025b689a9250efaf20bc646fb618b"
SRC_URI[sha256sum] = "161b2f887cc39d02809ca69fce3b5b53b7b58d3edf05a7bf81dde0fa8ed45f46"
