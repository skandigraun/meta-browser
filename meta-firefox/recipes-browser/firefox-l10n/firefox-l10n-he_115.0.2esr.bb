# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "566a55698c264c202955545883c035c7"
SRC_URI[sha256sum] = "29ece5ef4623881e2aea01930712f7254d92a5f890ae276553f548728c93f797"
