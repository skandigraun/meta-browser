# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b02a4089304c131a4a704b38c97ffaff"
SRC_URI[sha256sum] = "45aa1259ea9e4636e3441f06d4a57a155e28b017be0332c4c0179901ed351b6a"
