# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ca47a0c2fa88175fe3b6add7243b90e"
SRC_URI[sha256sum] = "d424bd2efc26a69dd179d4f6f5a1b4053ff88b9ad36753dba50e33213582bb29"
