# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32063620a4a7714c51bb4f33071479f2"
SRC_URI[sha256sum] = "9053d7f864f5023bc637523e0b1b1abc5eea552365840bc0d06d5bb85535316f"
