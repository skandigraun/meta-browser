# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ce4e6bb9f27bb554d9773e4dcc8db48"
SRC_URI[sha256sum] = "f7698357515576f74ddc7bda691e20e92e115ff93d15ca0f67c854ddd8b87510"
