# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5745f3b79e815df1736dd28d48fc7145"
SRC_URI[sha256sum] = "c10b5acf667d3fee4ea73e718a703f46dfdb8f0d53a85b05144ce7f2c0d9a476"
