# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc512e87f183bbe8f42ee316e675df14"
SRC_URI[sha256sum] = "64c47192eea4c31d0e57dcbde62f896e5d419d72bd5591bdd94ad5ebee9dd322"
