# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0b374603c644c8fb7b7d1cbbab63660"
SRC_URI[sha256sum] = "85a410d2ae06b1e66ab17fe65b389440866f360c54ea72511a29c172d00ec05c"
