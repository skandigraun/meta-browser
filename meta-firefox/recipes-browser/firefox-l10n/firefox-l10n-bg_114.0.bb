# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03b4ee67d6a567e5bb8df177664d3952"
SRC_URI[sha256sum] = "38e9cccd6791e769fd9016c2e0a3d5aafb6a2090c1c60326f03907aac0991325"
