# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd88022fd3fdb3c18bd604004f64e686"
SRC_URI[sha256sum] = "a2561641f64b428f34ec4d5215b97a6ae945df31b347c282e4f33a1fe82c5bc1"
