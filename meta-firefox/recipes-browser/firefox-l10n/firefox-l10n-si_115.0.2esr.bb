# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "845ff8468eefd282e496d97658dc87b2"
SRC_URI[sha256sum] = "66b273d22dceb149f425f5c11153b7f877e327e35b56cd635d8845bc1c3a99e4"
