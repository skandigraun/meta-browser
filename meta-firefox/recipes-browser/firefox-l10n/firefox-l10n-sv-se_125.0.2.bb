# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d80e72e57b41f39fc008fc9bf558d8d4"
SRC_URI[sha256sum] = "37e90ef14dbdc18225f9aa2c8e9a3a42ab4d39c5aada210cbafdaba40f7156d7"
