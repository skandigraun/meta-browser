# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "680926eac703d144c0fc1494532a38a8"
SRC_URI[sha256sum] = "af0b2f83ec220a2e0c733d04a5f235974be670b81b195568f9a9b7e4b712d417"
