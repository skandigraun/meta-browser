# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01144580bf823437cd461cf14d283577"
SRC_URI[sha256sum] = "093ef31bd30e711faa7370082a1845cd4d4aec9686aea9524fd619b02cd2de81"
