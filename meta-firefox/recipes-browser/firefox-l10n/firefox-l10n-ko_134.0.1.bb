# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82bd0712cd960560f4947496b5afc31b"
SRC_URI[sha256sum] = "cfc6a6db8d86811442ac229da18a90702478919aebb906476bf1fe0994784579"
