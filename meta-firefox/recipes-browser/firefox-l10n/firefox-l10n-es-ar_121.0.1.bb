# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "947dfea11d402498279a47041ab23664"
SRC_URI[sha256sum] = "ba3aadae93b391735b4a5a0041435be85be424d8fc3cbc2a5bd1f9985cdab21a"
