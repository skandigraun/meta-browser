# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7023823e59724b08105939ea1282ffc"
SRC_URI[sha256sum] = "93d4c0ae6ff56ecd0c0acd626480a9dac8cfe862b535af7235e68f53e486f605"
