# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f95f06e951ac230cc31af807dc4ad0f8"
SRC_URI[sha256sum] = "3e1cd654144fca33f5435a96c2926d0775ab8888835107c71b99f882e0c94ec7"
