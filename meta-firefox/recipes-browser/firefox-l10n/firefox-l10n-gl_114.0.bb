# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c23475deadf2bfe8c76c6670d970808d"
SRC_URI[sha256sum] = "e9a5d2be6f3e69570abefcf58390ffecf911efcbb096601f6ea326797d9950e3"
