# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1df1084f12d9aa3e18705dd921d763d8"
SRC_URI[sha256sum] = "09733ae769d6974159b4ee82933ef4dcf74586d5bebb7a36f1e9b3600da4293a"
