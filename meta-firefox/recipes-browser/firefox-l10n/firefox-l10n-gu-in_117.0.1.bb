# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8805858f50524865410213e724857344"
SRC_URI[sha256sum] = "3db5ba3c26d8c9d744163bc834c05b3d17389a4427c966113741e031aa322dec"
