# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c7c1c200db4c5d31f64604b88c36327"
SRC_URI[sha256sum] = "82bf4d9468eb6e05141783d65375d9021ddb8a81ae6395ba7e45a1e417f89a00"
