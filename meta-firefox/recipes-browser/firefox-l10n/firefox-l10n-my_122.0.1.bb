# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9c5b40846ea8837f17720d04e4f9cfd"
SRC_URI[sha256sum] = "b2e35f6daa8c231dfe7312c6c37dc47f021632b056b44ef8dfb0053bbe9dfb6f"
