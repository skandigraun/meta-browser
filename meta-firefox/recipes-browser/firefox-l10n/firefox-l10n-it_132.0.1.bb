# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de43a3c12b502f63ea51c82de5aeedab"
SRC_URI[sha256sum] = "7304ffc727808d55fd418c053921f998b19650e4a017bfca8a0307d16d768201"
