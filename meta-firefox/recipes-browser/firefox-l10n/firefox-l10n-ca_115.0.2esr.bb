# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73b8260ce1a05ef989a3605eb2231eeb"
SRC_URI[sha256sum] = "ec48bab548e2568032f2158f822b7117de6857c86fb172db318ada007fe6551a"
