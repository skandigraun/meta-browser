# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f9fbcc0e79312b68400113708c3e9a4"
SRC_URI[sha256sum] = "b347a39f2f98b2aebd2ab4779e4d60d3bb1a54199be0de33d3eb044945b7f643"
