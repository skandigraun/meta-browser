# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5096dac6f759c1f0c26906dd200b1caf"
SRC_URI[sha256sum] = "26f6c5be812bd622191899d2aa0d4d5cb4a1aa934eecfbd3b8b5d093e103b1a0"
