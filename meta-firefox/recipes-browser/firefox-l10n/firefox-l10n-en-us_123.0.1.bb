# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcc7e95d85fd6d4969dac4e44de80738"
SRC_URI[sha256sum] = "86ec5f464d4a49f6bd4823642d5adda6b01d0a12f952056b079dac0a8b45c33c"
