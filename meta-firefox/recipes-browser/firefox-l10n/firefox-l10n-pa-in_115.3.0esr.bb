# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e443d87669bb026aa5987273fe42abb"
SRC_URI[sha256sum] = "8619f56941c909e7ad3b167c9380ad8e0f69d582b819b0dd6f90c30af75a6ba3"
