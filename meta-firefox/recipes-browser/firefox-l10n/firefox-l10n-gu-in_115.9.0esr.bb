# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "375324d07d87bbcd101a2f830b1dffc5"
SRC_URI[sha256sum] = "20b8969e3f30e626bf65d87c023f124caf55b5eb408efc1e80d7b502f8542335"
