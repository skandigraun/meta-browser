# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6af9eec0395db16826fbc8ade137ac64"
SRC_URI[sha256sum] = "6cd8ac4a2a775679141940caaf2c0f843063de71b905d2fdd1a83f79b92faf73"
