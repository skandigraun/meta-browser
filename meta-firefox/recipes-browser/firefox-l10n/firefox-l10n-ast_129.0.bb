# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85024a902ff3d0a0ea26db5d5ff8b0b2"
SRC_URI[sha256sum] = "4851db5ce05c81d56bbd2668f7aa6d550e3e99244871b69af91e5462e3b43819"
