# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fea1c8c843a0e2b991adf7eff72c748"
SRC_URI[sha256sum] = "0bbead8dd537768c84ac62b455248907d66f78cdd5a2f4227b0fe453ca2932e2"
