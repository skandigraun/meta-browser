# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bea8499bba668dc0c3bc6ab5c92c079d"
SRC_URI[sha256sum] = "5bf8e0ce776e0462f5781d902d76ff8d9b0d02980de163dbdeb1452ae10dd492"
