# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6f3e9e3dfb26002f390f88069099a8d"
SRC_URI[sha256sum] = "35069655fa05654b767c223a0303ace944c2bcb166a2b296fd5a9345ed20ab87"
