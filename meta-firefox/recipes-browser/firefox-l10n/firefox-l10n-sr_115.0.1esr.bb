# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47070f68a2c32216820666f6c30c69b6"
SRC_URI[sha256sum] = "8ca1fb148156eab3edda871a754333bbca2ae19b2a07c8075e87edbf956a2661"
