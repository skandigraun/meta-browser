# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e69de4528e83b194f65d6b7957b401f"
SRC_URI[sha256sum] = "b5f6aa15bcab83e7881e9d9263e5e8106724b23887f72fb6c7f81154a3e7485b"
