# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d559fc54c9729f8f53b8ae2689502a"
SRC_URI[sha256sum] = "2e73da78e2ac5a6ce058191e6598a6f1257728ccbc88aed624aa017a5eb1d8de"
