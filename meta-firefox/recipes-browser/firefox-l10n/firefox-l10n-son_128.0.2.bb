# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "135983e7070f03e87bde725d8f5dd4d4"
SRC_URI[sha256sum] = "bb574a276d629a5d21b9bb5b430b1470dd74d4a7be66cd8c8f945dcfde59d710"
