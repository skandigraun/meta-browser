# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e2d16ef83cc0336941d9a8ae63c783f"
SRC_URI[sha256sum] = "e044d2e244839d80998416d63f9895522d3690aebc267bc810db35697e09da51"
