# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f9d55d8c054d97a6b180b120634c6fc"
SRC_URI[sha256sum] = "8a2dbeae6a0b4df1639b37d75cb94b98e66aaab6430aacfe24faf61eaf43e616"
