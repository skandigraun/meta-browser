# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e08fd2cc026dc17df2c260eac775fad"
SRC_URI[sha256sum] = "b6453b5dc07fae547224cb675d5bc4567a0e715afde2df80cd1b0c4835475079"
