# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d0194b857635ef89ca8abd328386b22"
SRC_URI[sha256sum] = "98e7e58754bddbc736144cff0068f48fd842d0de85b52a02c422f7efa2e02d6c"
