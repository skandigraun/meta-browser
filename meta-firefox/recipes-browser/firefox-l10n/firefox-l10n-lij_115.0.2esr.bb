# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12844c707c7a318423b7d86788f755c7"
SRC_URI[sha256sum] = "fcece4a778015bcbc46b929b205302e56f10b49f2622124bfb4f9da8ed9f2eda"
