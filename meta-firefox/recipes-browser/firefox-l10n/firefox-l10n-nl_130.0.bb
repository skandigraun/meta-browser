# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41c83cb1da123ca0cf4c746330a52a3f"
SRC_URI[sha256sum] = "491d92c0c53c4b5efd40e9f6b9f385b5b6c0f8c0bb6c0d2222ff0c5d97976c5b"
