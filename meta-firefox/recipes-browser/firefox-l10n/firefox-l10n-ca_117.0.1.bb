# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7ced79c258e7cf30a5607fc1b62d9af"
SRC_URI[sha256sum] = "6f1b7d373d3f33c6caac4a2544482aa6551e59b6c3d80b302d77ea6c9527e889"
