# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30df70ad44a72695af9bf65e4d69863d"
SRC_URI[sha256sum] = "8716c34d419ef8488585cef72b165b635a76a7547f2a5e5a57f140629f6c18dc"
