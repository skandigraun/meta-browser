# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86bf5d9381af6b5cf7152af6f55dfad8"
SRC_URI[sha256sum] = "f835b7fc1c2b54b9b10c62096db8d28e06b901905fd92fca28e5fdba2b8418cf"
