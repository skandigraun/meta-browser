# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d208cede02f822ad681d538e95af715e"
SRC_URI[sha256sum] = "34e98b02319cddc3928591d3dd74f943738c2fdf3886ed9d1944ff7f8eeb50fe"
