# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ecb195f63cffef2b8cd3611ee231c0d"
SRC_URI[sha256sum] = "81d5016e97ac766b1950e74526ff802d16cff538761af894b291c6c81f1212dc"
