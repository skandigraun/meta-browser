# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09a15ce8a1f963183dbaba0f2ff726fb"
SRC_URI[sha256sum] = "643f5e08d9b64160f883e349b1975c2ac73c1ba5bde76ba8f438745d730872ac"
