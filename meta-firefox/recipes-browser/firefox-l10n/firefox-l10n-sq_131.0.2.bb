# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81f0da8cab211554c78652b0b07355f2"
SRC_URI[sha256sum] = "1ac24e31f1ae6cb8a7931e77c16d2dbd76d26b24a913fdd037f04cfa9bca5bc9"
