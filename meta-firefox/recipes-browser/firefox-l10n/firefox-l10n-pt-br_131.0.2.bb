# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bc9b3130103c85315e024d19f06f8b3"
SRC_URI[sha256sum] = "1a503c0c8e73ea69a05b914b512ec9c463f8926677c0c53bbf2033cfc149be72"
