# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9117b051af47ff9eb9b8bd957a57ff3"
SRC_URI[sha256sum] = "83875f84487c32f596e988397c34ff7149e73889b971495f027044bc7a728b88"
