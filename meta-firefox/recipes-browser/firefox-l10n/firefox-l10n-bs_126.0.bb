# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "130551b4057e38c194480056740b1469"
SRC_URI[sha256sum] = "eb5ee176624c3d4329a38ea5521a68da6b88ec3f5e73b91cbc13df0a0d25bcd4"
