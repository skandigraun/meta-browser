# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfd1cfbf3bdd3ef3f82d7ffa6a523c3b"
SRC_URI[sha256sum] = "e0be6915c9a3a47e7cbd359a5b18572e58456d9525e66d1442ede391de51f7c3"
