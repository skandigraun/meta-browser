# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4556b54a164ebdf9d68590328a125ec"
SRC_URI[sha256sum] = "f9250730f4f9e4f5bd3901956dc795002dd0d45ef86878d54933f4699cefbbe5"
