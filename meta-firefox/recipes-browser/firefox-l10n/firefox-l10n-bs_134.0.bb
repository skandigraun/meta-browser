# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "769883deec48e437ced060ef7d98f7f0"
SRC_URI[sha256sum] = "8a6bd122fc5bd5ccf063d2d5613c124e350a5d5c5a12e14142309db7f447da7d"
