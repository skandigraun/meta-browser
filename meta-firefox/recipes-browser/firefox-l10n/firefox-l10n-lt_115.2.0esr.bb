# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "493c12afce08fe95fb4e73362835c0ac"
SRC_URI[sha256sum] = "c64d34656085cd32d0d7afdedc9e1345dec4f1e18edb2f053474a79ceee8d24e"
