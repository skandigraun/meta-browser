# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca506c60dc11d2aa9dd27e325bcfbbd4"
SRC_URI[sha256sum] = "fe4f45277ec90f393d98867f8f5ea94f72765537019f9f1f8515e176a8e0ca68"
