# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceffbfd9c7434c32215e6abbaaead70a"
SRC_URI[sha256sum] = "56e105f83f141a835e521bdd91207a1c36c24dd55c21f71324bfe2f5461a1108"
