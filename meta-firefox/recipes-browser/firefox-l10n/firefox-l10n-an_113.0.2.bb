# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71c749374cd609cf08970d53e54d4952"
SRC_URI[sha256sum] = "5498c4f1d759ed74a398e3f897e6e01001864d265fb57ee6dddbc011eca5d078"
