# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c343cfbe5fee499001d925859a089cfe"
SRC_URI[sha256sum] = "dad3162c60229235d98c75035d489212bd0c8067f773818a2e6302108e3a5354"
