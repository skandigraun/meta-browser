# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80121062d67647c9c32015fb60f1fd06"
SRC_URI[sha256sum] = "4bfad62b11b6a638a96a3ca704745e22e35e6a6b6ddf0bf15492cfbd6c7d6f43"
