# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9fbf02a99c9eda10b706655c9cdc148"
SRC_URI[sha256sum] = "311345bf8ce9da85cc2172200173a2b4f549a0963d682e09cb1c3a7efed3e607"
