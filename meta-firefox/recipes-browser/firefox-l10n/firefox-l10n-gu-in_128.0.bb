# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a8852171e0a87bcbe6d29886bb527b96"
SRC_URI[sha256sum] = "6e786c965003d74b166d1c90fba761d111a943a5f627e1571111b41a387fd21e"
