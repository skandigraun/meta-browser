# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bba71197f0287517c6ebaf2fa27e1034"
SRC_URI[sha256sum] = "52190104f9bfd34c44a73b8c8cfe64e8b2753117be5629ea02e7958ca229a3ed"
