# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfa5ea7ebc0ac6a360bd079206f2e6ed"
SRC_URI[sha256sum] = "cd25bf037b613c98166b6fa847e8918c98ca70b0935a04673f5ebcdcf6a68292"
