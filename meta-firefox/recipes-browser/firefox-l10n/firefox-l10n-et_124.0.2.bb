# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c968b6740711c30f6de8354f5da74f4b"
SRC_URI[sha256sum] = "c11b9b5f6f3f4790c1dc4dd542fddd0b9dac565ac25ae78db195f575dd42ac8e"
