# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2da6dc669f7e13a8906ee7e3b4fcd0fe"
SRC_URI[sha256sum] = "0710043c0c3f2d5f5d1b39423b1a2e1d79db70a97179ea87bcf1618d8e99baff"
