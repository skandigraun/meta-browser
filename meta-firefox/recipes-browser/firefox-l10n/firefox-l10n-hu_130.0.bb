# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45022e059af4c94f73631b01a84a05ba"
SRC_URI[sha256sum] = "df0979d4b518f1d9baff1e049f81516665c2edd18885e693e7a52c397e69c9d3"
