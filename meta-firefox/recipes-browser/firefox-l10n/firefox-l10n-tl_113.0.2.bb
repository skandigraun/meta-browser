# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "718497eea16395e895235604ec8c6357"
SRC_URI[sha256sum] = "53365d5f1f0421faa9367293ce97d35fb4faeee7d0f7a869c5633130125d4084"
