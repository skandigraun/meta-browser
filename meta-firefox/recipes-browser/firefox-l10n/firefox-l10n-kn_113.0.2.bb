# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0709c66a13b72cdb5ef7c0d2881dc734"
SRC_URI[sha256sum] = "0edf65de137c213964dce18708207f84135657758cadaaac57324e44b34dd9a5"
