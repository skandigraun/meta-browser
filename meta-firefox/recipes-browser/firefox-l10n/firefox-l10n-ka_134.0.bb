# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5add1329cd59399ea2282e2c9391728"
SRC_URI[sha256sum] = "a42aabd098a040ffd690ebd3d2fc551894494ca97a2ece2c61ac8f0bec05bf43"
