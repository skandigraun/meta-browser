# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd609e3b51beaacd5234598db1daa84d"
SRC_URI[sha256sum] = "b12bdc73843e772d9dc3db8d666c191773efdda90ed9f82a649fbf42250c20e0"
