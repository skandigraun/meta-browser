# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca6e8919aeef5d755bab1abf42b20360"
SRC_URI[sha256sum] = "b732068840d39d20e8b5d1dcee23216ef9081fd576dd8dc5c3fa7cf2df10c2c0"
