# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98f349065b1e63b50a44bf81c77b1e3f"
SRC_URI[sha256sum] = "e7b732af30451308ffd1a2244613950d8111f27b2ac8b465831c176b793cc778"
