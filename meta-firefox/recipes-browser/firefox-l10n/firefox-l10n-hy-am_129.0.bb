# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1be47f698124ad9bb7b0e56910d9402d"
SRC_URI[sha256sum] = "c74772348a2b0eaa76305cef45d2198f553c20faea87d2db8b6bea0492132ed9"
