# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e03d502292539cbedc82495cbae631b"
SRC_URI[sha256sum] = "37b7a2fc3aa1de69b480c54d039c8572a474f0396deab825165db2e8d471b1da"
