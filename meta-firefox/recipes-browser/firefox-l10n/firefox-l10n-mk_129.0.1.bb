# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f2d52c32a2f7e14954ecec1a3047677"
SRC_URI[sha256sum] = "a961408140e606640a3fa1835c7a240a32811ff6f49735065ba52bd2136a83c1"
