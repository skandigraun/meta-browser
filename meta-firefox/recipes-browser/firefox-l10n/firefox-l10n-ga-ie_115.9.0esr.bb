# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8497fecb4d9d0ff5bea1a7613dd70843"
SRC_URI[sha256sum] = "8ff07014220538f0498ce450256f9fd499a9c5759dee4fe4acd714aef7ebcab1"
