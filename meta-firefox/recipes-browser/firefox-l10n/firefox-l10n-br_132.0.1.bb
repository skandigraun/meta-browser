# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7ca81b2880fb7630af23b4a7ef4ad6c"
SRC_URI[sha256sum] = "2296482c96d22257637b9ce3205e85340a23c6707c3012c4bd1e36ef0bfbe0b4"
