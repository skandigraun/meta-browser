# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be6db61bc564109f1dc85f8bbae008c0"
SRC_URI[sha256sum] = "ec62ccc072d81a02fd627500f13e89e2ed387cf1fabfa05891324e4c3f77830c"
