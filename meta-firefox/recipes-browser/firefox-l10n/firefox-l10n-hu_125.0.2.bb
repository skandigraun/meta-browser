# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d261728e39c1838e0293fd350889ca8"
SRC_URI[sha256sum] = "117d6db6c62974a6749c624780e4c719f6319c1dbd4835204cf9cfb49be28dfd"
