# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d4ce8a043c71efac3e8a3a38b823534"
SRC_URI[sha256sum] = "7360eda6bf5cba886d2af093b7eb88303110e7620e34971914cf74cf4f0815cb"
