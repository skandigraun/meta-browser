# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e36b7db07205adeead9df9e0c29d1cb"
SRC_URI[sha256sum] = "a09373592d9530ee9b24f08367f3df18dc04db382722d6336b9988a8c25fe9cd"
