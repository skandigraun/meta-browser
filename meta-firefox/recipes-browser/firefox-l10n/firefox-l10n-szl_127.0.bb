# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89f37c446653a595b2c03504ed5e355"
SRC_URI[sha256sum] = "408a3dd4e9346d623d252b282dd9d0c28a7d48bcf2c4ee11e106d16d252c1059"
