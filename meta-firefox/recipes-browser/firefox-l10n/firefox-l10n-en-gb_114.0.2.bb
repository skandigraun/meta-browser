# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fae964d999d915de7173980dd5e41334"
SRC_URI[sha256sum] = "4b1d83a295dc9f029c55b2ea519322d0b04f766885be5f0c16433da8eb61ddb1"
