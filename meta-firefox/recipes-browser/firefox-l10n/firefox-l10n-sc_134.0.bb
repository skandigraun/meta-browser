# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "835106ef132fdcf2d0ad3eec9646bdb1"
SRC_URI[sha256sum] = "36cc1c97463f1cd2374ad3f2167b5f801c5efb0abc4c70e5ba819c3a44519b2b"
