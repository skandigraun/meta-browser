# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29c92a5dd1cf6e390733120eb216a4e0"
SRC_URI[sha256sum] = "b5ad29fc1bad0daa8bf9da97d9d78add5603e5f26c43e9ef6cbf35cdced7b5c6"
