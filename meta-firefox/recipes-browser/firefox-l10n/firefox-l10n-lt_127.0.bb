# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd0b68e750d6566255cdff0c20650f9d"
SRC_URI[sha256sum] = "df5d2c78d35edddd4b0e3b1991daa23f758b072b57dbd0f918648af5c2c9b302"
