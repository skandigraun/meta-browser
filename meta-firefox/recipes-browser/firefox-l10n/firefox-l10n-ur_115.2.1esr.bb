# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "218079f2c83ff4e28f943e2da5140d78"
SRC_URI[sha256sum] = "faea17541e9d6b60aae2864be0a11d22eb11f63937b1f897977305c379cd8e8f"
