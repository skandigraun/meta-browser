# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a4a041e3fd703dce200f23dfc477ad8"
SRC_URI[sha256sum] = "9d8b4396d6ed23a7753b82bcfab1646235b2926efb65e548f56fbe67e1ffdf2a"
