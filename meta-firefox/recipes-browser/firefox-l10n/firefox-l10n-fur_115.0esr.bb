# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a4f376d01db1253a87ca58fe08c2abf"
SRC_URI[sha256sum] = "e6e5ff285cefec1ea1e69a4e29b469f35b845bbad44a4f21704f15b1b6be96ef"
