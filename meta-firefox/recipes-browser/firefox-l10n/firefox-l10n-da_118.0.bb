# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4076be3e35a5f62ee619b482192ba25"
SRC_URI[sha256sum] = "bb2cf743dd00c3395c1d46b76539abfa44ade2054afc3e542a3bde7724daa3d7"
