# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c53fdc7abb2d48d6be0c380dfeb4fdf9"
SRC_URI[sha256sum] = "54c85f4a11445a05cb030fe751b55cd60639027baaff8f7d2804b66ba8e19a05"
