# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3427e915ea5f3b5ded66f7ba734e8323"
SRC_URI[sha256sum] = "d2f80bd253b0de03ac295151ab5b33017c432c2a3c07d29bc7f50437bbf4b43b"
