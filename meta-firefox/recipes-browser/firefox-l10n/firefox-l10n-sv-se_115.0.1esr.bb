# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b954eb7ab8c38b3fa6b98c9dc52b05eb"
SRC_URI[sha256sum] = "3b0d42e61a446a5fa31bcba94a77044f498acf22769d08f15bee3396753a3c63"
