# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d7f609a6a292dbd30672c876e595945"
SRC_URI[sha256sum] = "2f3e1f1230176ba28fda07d3c3b7afb98f51a7b4b9df6de6f5a7c4eca3e37f45"
