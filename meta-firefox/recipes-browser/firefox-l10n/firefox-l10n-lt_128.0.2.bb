# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa8ec4a22efb34c0aeb6850614ab0038"
SRC_URI[sha256sum] = "e149f79a10e661b933b4559707ca04227172533fc43d87178625e00b36088130"
