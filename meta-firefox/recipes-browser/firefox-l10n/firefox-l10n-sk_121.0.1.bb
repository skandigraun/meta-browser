# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3b945a2144607f361011a40687b382a"
SRC_URI[sha256sum] = "0732a717616f36b9ed8508e5358d4f976cf2e83688535924611bec74e7cbb012"
