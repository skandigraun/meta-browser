# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8e79608b6e8bbae029f1c1194d571f2"
SRC_URI[sha256sum] = "c6804c054aab7026aae0fd5522c65144b7297e3e98a713d71ef71de2dbadbbb8"
