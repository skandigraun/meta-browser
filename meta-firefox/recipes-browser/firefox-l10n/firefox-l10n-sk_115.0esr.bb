# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94fa77390b346b78d41e95a9065766bf"
SRC_URI[sha256sum] = "b1f282be40bb8c032ec464898cf6fc04283aefaae3f26ca1cfdfef33712b09e7"
