# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc3c0fbea68c5101437e5eb395864c91"
SRC_URI[sha256sum] = "3652ec39b34152368911b755ada4769086e12a22f3f0206f69d56e8db9dbec58"
