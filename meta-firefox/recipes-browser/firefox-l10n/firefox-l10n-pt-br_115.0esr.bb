# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a31a097c634de129d0319bb83f49f66e"
SRC_URI[sha256sum] = "d0d83e9d96934f240e51072f67b82db131c5a17f1c688a4ad91b1a07fa7485cc"
