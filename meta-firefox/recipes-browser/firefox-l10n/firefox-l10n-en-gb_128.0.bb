# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f5b98210b26e3da9131c91565fbecd"
SRC_URI[sha256sum] = "1248d554ca603550f8c2ada130567bcc6f3a7013dfc2d9efc12bff7240e1f642"
