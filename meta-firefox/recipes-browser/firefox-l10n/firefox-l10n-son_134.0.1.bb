# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88d3d79794cae2d065bc1eed4d8ac8d6"
SRC_URI[sha256sum] = "7d72c1c1d7cdf1b2086bb82a9c3b8cedf88530fd2b79bdc6944770ad0310da91"
