# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d5e6e084ca0b5bacf3575f29fd1bdc7"
SRC_URI[sha256sum] = "8fb6a1117c561cf3653b1ed418a0ccd0d07c31930b2213f816e7bbf456aa8d50"
