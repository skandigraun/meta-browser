# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d102a2aaae8de3cc319d4a005554c4f7"
SRC_URI[sha256sum] = "858c27bc8a06a234643b22b47dde3496ac69d0d53794b189ddac824879bc188a"
