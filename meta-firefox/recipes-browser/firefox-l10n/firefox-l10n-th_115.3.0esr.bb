# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0f3ddbd75700eb28a2516c56fb6b1b7"
SRC_URI[sha256sum] = "bb8cebcb47e15cfda489504127d34bb30fb9d4b6ebaf737a980dd5562974f5bc"
