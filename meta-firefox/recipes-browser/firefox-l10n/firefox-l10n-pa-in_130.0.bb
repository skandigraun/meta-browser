# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72fd2fa4da404896d04542ae9a5ba297"
SRC_URI[sha256sum] = "3338fa6886107d75cc055ea15b0e59257cea7e5524ea5f32355b3ba722de21a6"
