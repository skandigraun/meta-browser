# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf92b19a1e98b2208d47d7d78f6f20f7"
SRC_URI[sha256sum] = "2b52281d5a4f6d2499edfdb24bcdc10ce0f074bd51c14c6b0c1363a7e1339bd5"
