# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ac9ea508e45a8e4d7e7d0e4173b85a6"
SRC_URI[sha256sum] = "aa5c4229e51bf51d65b23fb506579799f694decf2b0d9c2bba1f429a8fe48c9f"
