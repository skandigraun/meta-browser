# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4681ac56c7c94409f06bf2572d85d17"
SRC_URI[sha256sum] = "1015dbb8b67346cafc76c316599489fa246b9e19f45a2eddf0982d76a44090d3"
