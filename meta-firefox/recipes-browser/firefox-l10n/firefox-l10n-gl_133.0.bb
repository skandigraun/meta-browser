# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cdfd8d0efd999c12dd49c0ea8671894"
SRC_URI[sha256sum] = "b7f0676603c0e89ac6b3b0fc31e8ee14324a627b9f3b3c25d3a965d9d86dbee4"
