# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "011adec5334741fd1a8ac043977d379a"
SRC_URI[sha256sum] = "54e08dc0b94216aca0b6ec402dba86a86f9dc4bc1a646192ae2df68a183177c1"
