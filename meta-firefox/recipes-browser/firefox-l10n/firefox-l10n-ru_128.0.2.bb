# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87d0c788c99e30a255e4ac2062476585"
SRC_URI[sha256sum] = "96ce62af2ac276145f56bcbb10fd784e31120c47a56556fdc9423ca73cad03a0"
