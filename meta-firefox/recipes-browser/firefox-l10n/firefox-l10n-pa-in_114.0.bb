# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94c71989f72474973d240ef0f3293714"
SRC_URI[sha256sum] = "1eadb108e6271cd74ef0a3328dd277cb92765ff0b8d72d922a979d0ed9710944"
