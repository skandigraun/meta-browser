# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23212f34e4ab457dbd66d68ec366ec25"
SRC_URI[sha256sum] = "c9be422458a6bc0db7fe76f8ed3fa5038bbc076f2cb2e833fe583a499f6c0ae5"
