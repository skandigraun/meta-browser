# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c54d892cb05706bc0d914fe44e001cf"
SRC_URI[sha256sum] = "9dd27f6f0bf89a2eaed417569656369eb09d832d18542d844b5248d9eb5f367b"
