# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4afbc07840b658d0b3eec9292135068"
SRC_URI[sha256sum] = "c8cc97084402f2ae90e538338943617a896c802a5f8c24edb8f58a2cc5ac2fd6"
