# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "add9ad9f9ecb354d6b77f4ed8403ad11"
SRC_URI[sha256sum] = "02fab32d83b429d27a2a5c9d7c734af8cfed9317e257e45d501b700d155d65e2"
