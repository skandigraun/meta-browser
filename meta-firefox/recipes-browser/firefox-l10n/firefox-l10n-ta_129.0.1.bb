# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "646c5334b16024e246a0da6e20554409"
SRC_URI[sha256sum] = "7ff2880cb2bd8c16695b13a54b51c0596675667e067367735752bc2fb744300b"
