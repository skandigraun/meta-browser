# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55fb5b02f970a2e14b3ef912b67c18cb"
SRC_URI[sha256sum] = "11a3457797ad8b92fd8096111343cd9f146ec7a4572048696b654074d957ad9d"
