# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "501ba14b616eb0f3ca17e84bf441dff0"
SRC_URI[sha256sum] = "6da5dd62dc44b1bad6fcadbf2bf7fa8024c6d064efb11a031ca4575b9cb4aae7"
