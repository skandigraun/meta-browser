# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a439f41fefeb126e45acf51e946964ad"
SRC_URI[sha256sum] = "8af14f55f5b493b932cab215147e152ed2d699025894780277d3ed4813d748aa"
