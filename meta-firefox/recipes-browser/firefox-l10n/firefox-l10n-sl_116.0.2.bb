# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9c9c319e521e8f029258d9dbb835531"
SRC_URI[sha256sum] = "64c4927274f523e5cdaace751c1cf41ab888fc0adcd4ce19b96f71536d8ba2dd"
