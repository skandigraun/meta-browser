# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f152376811863868ad9da07c675789cd"
SRC_URI[sha256sum] = "225a6bef954fc855408bf81c39aa1900d9f95adf1a902a3ca59c66641e4e3ea8"
