# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b3232fd922d7823d23c87b0d9cd7602"
SRC_URI[sha256sum] = "c9300052ca16f591d888e4411f4aaab67e1b0e9c0975de5e08f90ab31f530919"
