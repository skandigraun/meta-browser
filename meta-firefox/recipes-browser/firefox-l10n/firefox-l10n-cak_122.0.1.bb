# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "590fab2ddc38dbabe6788ffb8c07d4e6"
SRC_URI[sha256sum] = "03a5e0127428592b78e44f118eec40f03e36b7695894f4c8331e19872dee8e4c"
