# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f17687e3597bd2ba4db726d6af82b170"
SRC_URI[sha256sum] = "a8881672fb02102c936b5593c4764a4096a9d9c0f30ac53f92fe96d1d9fff5a6"
