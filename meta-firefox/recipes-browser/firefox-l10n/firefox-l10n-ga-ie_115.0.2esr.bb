# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "557626791d8a9a8a77d7e40727989716"
SRC_URI[sha256sum] = "5012e28ec526a9f880cebf45783f4580c4df60e8f809b78c71499dc6cbc42d38"
