# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3e91fdb9b6ac7b6f6d7dce0f4d4c9fe"
SRC_URI[sha256sum] = "4e6f685f4e96e433b3c07fb920033b1698382d5132a086cc7ffedff4556bc90b"
