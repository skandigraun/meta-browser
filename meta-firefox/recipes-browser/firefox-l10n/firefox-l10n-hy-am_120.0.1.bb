# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9cf68ef646fd2ecc7a4fe0b7724a52b"
SRC_URI[sha256sum] = "71dcaf760ced327a3b97b5c1899ae7736be237c6a6d8aa3359bb6d9b2e583559"
