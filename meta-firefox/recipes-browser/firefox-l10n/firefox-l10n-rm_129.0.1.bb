# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeece5108f2d56aba92f022f8db213d0"
SRC_URI[sha256sum] = "36d14cdcfccc49b622ee2eb959db860aec67e7f8ffb78035603901d265ca95a0"
