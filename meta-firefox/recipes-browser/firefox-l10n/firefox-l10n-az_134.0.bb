# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffec31951c398c4351a6201da3aee766"
SRC_URI[sha256sum] = "95d6f87db116b96c953e61439d43eb3e78b187fb147ca21166126c0de7ee118e"
