# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fd80dffbcf8b80bcc4787aef41af586"
SRC_URI[sha256sum] = "2f2d83031251888d52d45c558c672003c1fdc32c707443bd655797babe40838b"
