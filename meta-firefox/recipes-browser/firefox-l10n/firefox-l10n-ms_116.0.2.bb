# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30108b9c62ec5a562fd2d76fb7c6531b"
SRC_URI[sha256sum] = "3bb387aef54f6340a2997198634125d026d3fc19d79c627226774128dc653f73"
