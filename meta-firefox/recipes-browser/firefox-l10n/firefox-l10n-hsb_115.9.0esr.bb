# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41a1696cccf51ad379b3333beaa102d8"
SRC_URI[sha256sum] = "4b0e8d87d79e0d92cb75afaa285026726127a7a08350ca93351049ee538cbcbf"
