# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3efc4e9033facce0e2cc0c9eae57e14f"
SRC_URI[sha256sum] = "d8e730d6fb51970008af3ebd1e80ef11cb670a0d3bde7e51e0eea79a74b4b7a1"
