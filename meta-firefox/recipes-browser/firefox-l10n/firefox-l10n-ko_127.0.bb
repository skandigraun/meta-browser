# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c087829a695e747f898dd99c6549bd"
SRC_URI[sha256sum] = "b1381d8fe7e708cf2a06b399af6e1fd0de58d3b1dc4484a0066c34217230283c"
