# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2599e373f0ee8c75ae730d1372a878cb"
SRC_URI[sha256sum] = "1d2000856340ee50cc85a391193a40c6cd2bc6c22889db6e970835e607a9a07e"
