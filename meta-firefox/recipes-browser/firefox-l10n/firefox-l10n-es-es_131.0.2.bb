# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc1670ebe4ac833067b4d79f2232b180"
SRC_URI[sha256sum] = "7f96d4b6d0bdf71ccf52b3880a71d81d54f0c654a5b7580dfd561b13478d19ae"
