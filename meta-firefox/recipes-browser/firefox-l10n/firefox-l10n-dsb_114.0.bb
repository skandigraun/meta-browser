# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dce74315f759a9ff31e51f9406615c4f"
SRC_URI[sha256sum] = "c2a9d90d8a46a3f0070c031c48dcc09fcb33b8d571881578ae541984f0f98ff5"
