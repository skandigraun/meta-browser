# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff1f88736afc0e12900f1ad9286fd8a4"
SRC_URI[sha256sum] = "f748560caf1cbaf8fafb3ff9b6b071850e5d580220a005259ece7afe766c1a4e"
