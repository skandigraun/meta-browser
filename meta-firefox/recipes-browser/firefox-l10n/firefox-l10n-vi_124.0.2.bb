# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b27325818fe92efc4b3736449167bb46"
SRC_URI[sha256sum] = "6bfd792a41504284fac626cfe520113ff147a5daacb4d75c28f746c917ca75dd"
