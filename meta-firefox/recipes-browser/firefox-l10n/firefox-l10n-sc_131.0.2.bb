# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f660543781e548fcabb28f7b755520e"
SRC_URI[sha256sum] = "0033960e8fd569c05f8a30f2a296e91335e689b585e2ed15df12ae37e780a4b5"
