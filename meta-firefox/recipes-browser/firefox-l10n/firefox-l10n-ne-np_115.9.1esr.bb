# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72b8e7bf65a2b423e6dc0e4aeaec7c56"
SRC_URI[sha256sum] = "d4182cbf40c78c094c30eece724810e3c11b0e3c04d068d207fdda1ef92fc4cc"
