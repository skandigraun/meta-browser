# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4320fda8c1625a3593ada235d7c47b01"
SRC_URI[sha256sum] = "1e2abe87990e03c39233a0823388fa362b3c524e757bde0a91f5eaba36d8921e"
