# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd9f1f6a8fa4595f98f38d69e2748b7c"
SRC_URI[sha256sum] = "a4113d1e11b3bf080abd9e4858f53221c18dba16953c71415ab5d74b6b3473e2"
