# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b42961ca5fbce9ad8b235efb273578b9"
SRC_URI[sha256sum] = "611b76e988eb8b8f0821146133bbf8a8835d484aaff0b826033355a3f77e99ff"
