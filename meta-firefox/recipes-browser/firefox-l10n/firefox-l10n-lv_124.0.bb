# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62f52f721ca8e0e0e0bd2c0da2f9f316"
SRC_URI[sha256sum] = "1ac8d8fbfd44aae3745c30f6809e08ce559e4b925a0742fe458ae3841de9e5c3"
