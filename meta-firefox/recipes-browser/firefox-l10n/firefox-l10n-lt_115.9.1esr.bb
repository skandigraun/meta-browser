# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f16a2ce7e6f0c5fa87cf0486de9a9f5c"
SRC_URI[sha256sum] = "dd8d0f62d3b745c9a4fd1dafaaa8613861d732c6ab3ae501c25b5cdf716af12f"
