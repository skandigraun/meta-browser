# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e8b277afcea58d2e21009c070557cef"
SRC_URI[sha256sum] = "2479bffda92cfcc1ad972959a78de58b78a26c2f62fae0f9709b3bc65ce27aef"
