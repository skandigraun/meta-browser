# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87cf37c693cfe15f2e06ded60a5a1e44"
SRC_URI[sha256sum] = "00d96c98c5332e07fcea9793f795d2bd329d86f50d1d2f36a323a92f9aaacc67"
