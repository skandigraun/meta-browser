# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6794bd43020bfee34aa21fd0a4c255c7"
SRC_URI[sha256sum] = "d8a60f7a10a6e34c242ea3c2d02f38ab88d159bca8c823aed8ab26fa37497058"
