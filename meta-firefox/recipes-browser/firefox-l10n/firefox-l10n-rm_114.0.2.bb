# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62d0c31c8a99c9154a1ab75a8bf6fafb"
SRC_URI[sha256sum] = "07c34745a1c7e4bb88d618b5da516182c0490e411755ca1bd9bce0835041eb81"
