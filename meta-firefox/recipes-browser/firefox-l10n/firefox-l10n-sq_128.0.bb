# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a1f6c0d464a20adfecfa6a4c839bcd4"
SRC_URI[sha256sum] = "2b5103e62db9483599eec7861dab5ca7d6f49ff3dbf490f6c301465bbaed4332"
