# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1248fea8e5f12ff1a86d9345a4d71af3"
SRC_URI[sha256sum] = "268ba036eb232420a551d6ee300711a716e5d98a7af675ccfe4f557484638b4c"
