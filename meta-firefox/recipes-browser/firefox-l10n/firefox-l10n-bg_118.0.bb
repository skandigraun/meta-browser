# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c0ea7149fff3afa57dd3424b8ff32c2"
SRC_URI[sha256sum] = "2b715a26cc8f23afb3645f14007918a0a364ba892a86eca5283e08edb54c3a45"
