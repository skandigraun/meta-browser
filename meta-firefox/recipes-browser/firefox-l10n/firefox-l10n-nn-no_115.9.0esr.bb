# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9787222ebb1084c10d814616d0f1e980"
SRC_URI[sha256sum] = "e2a6d2d387b3bed700802d271c760228b743da8de90a087f35cb8f39a98bf93b"
