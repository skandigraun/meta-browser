# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a98784c8e35b04780041924891ad879a"
SRC_URI[sha256sum] = "01b0d521096bc58ee80c78cd6e37cd3243d879b25da12b0b1b648cd20c627aa0"
