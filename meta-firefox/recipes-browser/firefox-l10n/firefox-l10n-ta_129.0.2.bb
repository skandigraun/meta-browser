# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb8ec273f149dda7c9737c168d6d3ebd"
SRC_URI[sha256sum] = "e2ee02f17a12dfbfd7e1d28ea8aad505f2b1542c45134505960cca1b23dc3810"
