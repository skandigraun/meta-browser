# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5c1ab41a33f1f72c7463dccb98e44b0"
SRC_URI[sha256sum] = "9a74038bfc5fca53c1be44f351548c542f0acb48624f572050b5d0ca1cb24b80"
