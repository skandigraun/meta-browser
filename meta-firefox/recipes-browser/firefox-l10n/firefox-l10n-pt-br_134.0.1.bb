# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94365a5f7d4db21bbe9a951a0f890f3f"
SRC_URI[sha256sum] = "53d55c9f1ef64455599ae99800b9cf959a1205136b518b58321c4a7aa67346b7"
