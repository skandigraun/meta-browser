# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0eb43ee1ae16e20d8b735f5f55f998f0"
SRC_URI[sha256sum] = "850215c177a2e2844a6fd62f75b75c4c267cce8ccf62cdd7cf05dc8a38ebcb35"
