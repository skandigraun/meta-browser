# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb6cc1097c591b94ca789be66ffd73c4"
SRC_URI[sha256sum] = "1bcf7d625627c16b4821dd3c0346e48aeaf3528faf1f09b1dfb9ea64734febac"
