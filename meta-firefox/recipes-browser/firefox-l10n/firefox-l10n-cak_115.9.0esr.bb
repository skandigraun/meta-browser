# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "033c9ce5ebc204744b0b1cf231d25725"
SRC_URI[sha256sum] = "f3b93eb311b37a2747fe56ac3079587adcff849594490de22960d63deff8e747"
