# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "947ed1340e5f6040f616935bf97cdff8"
SRC_URI[sha256sum] = "01552ab112487115f0653aa97cfa1c8c93005b51ef1d04198305063a45cfa11a"
