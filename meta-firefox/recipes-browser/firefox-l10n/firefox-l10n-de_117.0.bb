# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1464984da25f3cc608ada5dd13d4597"
SRC_URI[sha256sum] = "374f007db2883bbb75054ee6694d707261a58bb3cb6c6663ee1975734eb5cc60"
