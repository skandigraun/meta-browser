# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bb0548dc1363efcf37f007f9d90f6cb"
SRC_URI[sha256sum] = "1183b420e85d228c032610472200c803250ccb24ee4356952ece8dd08145d34e"
