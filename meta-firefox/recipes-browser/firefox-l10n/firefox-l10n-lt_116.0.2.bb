# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fff1b4ee09435e4e92383c4fc2bb4170"
SRC_URI[sha256sum] = "a9bffd81668674a3c494d2f7f8968b56e3a818b8dd654d2400830b46944fd0fa"
