# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8ff46010c2fd3100d8ff4d1857b0c50"
SRC_URI[sha256sum] = "c22f4e848820353f35f01a3c37eec5ff582548c8f20f2e7c4b26d758bf6f65b4"
