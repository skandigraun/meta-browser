# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "182fa10bfc85ac2bbe8043e88836fc09"
SRC_URI[sha256sum] = "962144cd3d8c99695071908babac8707da5efbaa6302e392926435ea7fde5a9b"
