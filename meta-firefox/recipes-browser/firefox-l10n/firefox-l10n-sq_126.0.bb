# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae8b18864884841583dcfb20c7ea8d68"
SRC_URI[sha256sum] = "cd48a5b21065e4e82529d3e3a97e48367d8e1052d091249fb394445b728291b1"
