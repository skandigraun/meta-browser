# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fa0a55f6ebcd7116f106b0b0d2a7222"
SRC_URI[sha256sum] = "775707a66f0d0dcb78452f0af8d45146f8f150af96d67fa3f1d9dd7e56343224"
