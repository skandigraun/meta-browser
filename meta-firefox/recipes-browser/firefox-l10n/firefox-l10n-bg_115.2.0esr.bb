# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68b4cdf6deb19c36a566663259ba2ce5"
SRC_URI[sha256sum] = "cac11a95ec48a3a9e5e9a1f0a09592c5a81a798ebb663aa74f903e0ebf20707c"
