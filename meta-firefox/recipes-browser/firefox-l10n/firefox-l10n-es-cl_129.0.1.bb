# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fd722651d43cb841dcd384005a193a1"
SRC_URI[sha256sum] = "f997a049ffebd7b742f93bf6b5f1b3493c5197b339b0300f18d2842ab22825eb"
