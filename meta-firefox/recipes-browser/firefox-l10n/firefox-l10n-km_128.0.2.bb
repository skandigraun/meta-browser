# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60352041e92b3386f3a5425627eec8da"
SRC_URI[sha256sum] = "47f2f8c3536893451209926897e6e631e6bcbe096d15d61488053ba129b185c2"
