# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b27c578a596766a2025517c37d4356c0"
SRC_URI[sha256sum] = "ae0dc3349dcf8acc8fae3569fe89fc0470eb91a219e93039bcab061eb5db7a9a"
