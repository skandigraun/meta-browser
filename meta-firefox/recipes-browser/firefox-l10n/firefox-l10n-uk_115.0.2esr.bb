# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02169d0e678b73f05de8755fe4921541"
SRC_URI[sha256sum] = "c79924f2853ef396b8d751d8ba7be74c08be9e491505c579aa72f8161a113843"
