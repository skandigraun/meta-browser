# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64a99dd3d5498ef80fa73f664c1cfea0"
SRC_URI[sha256sum] = "4d3f1274da892de438c0d0e1003dd06509a7c21b60e7df3f91cbec463021a9db"
