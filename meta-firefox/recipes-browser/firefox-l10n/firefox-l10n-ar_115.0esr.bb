# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18b572f69de2d15616c2a7f20200026a"
SRC_URI[sha256sum] = "b08f0e0581e0cb6eb1b2d85ace37c8a0163f123ce23c20aacf683f4270abcb5b"
