# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10f51cd686c40d7a6e207899c50915ca"
SRC_URI[sha256sum] = "f188a74187863f79be6d129a684a4a0e18b877d0effc28c249e7784f56fea27c"
