# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a95ded296b70fffaffe55c1eef2c186"
SRC_URI[sha256sum] = "f384feabfbe86dee2bf204134737662ec5fbe9898bae55bdcd3f00380fb4c0ba"
