# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0fda449ddac9a8b4ca72fe561f4eaed"
SRC_URI[sha256sum] = "26cf07f9b447fa29348e7a211833fbea90c102b3d655795d415bd744621cc5a4"
