# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44a06fe3290e5e963b5f4ab7eb3a8af4"
SRC_URI[sha256sum] = "a07df96f0a8e74804989311d550b0bf427919fa9ed96bb101599a4e6f8aa004e"
