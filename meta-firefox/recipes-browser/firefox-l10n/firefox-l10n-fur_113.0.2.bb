# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26ab2e94038746a16719c70f82f96926"
SRC_URI[sha256sum] = "83552e4d986e119b1373114da666595c93d324b62cf9de48d25f7af17191a6b3"
