# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08ee4c6b0c061bf0ad814ee2d8cf9f84"
SRC_URI[sha256sum] = "2e83cde20d07e75d8bcdfe22eec744653f88f736dfcc7818f0deddb54f3a10e6"
