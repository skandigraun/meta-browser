# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9118efdb67a7b41f841943e9d3c8ea86"
SRC_URI[sha256sum] = "906d7d1f7283c9abeaa4af83c7c9b400c868e113b93508613ab3f40e0976e28e"
