# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b698d398da4c159ce703c0917a911802"
SRC_URI[sha256sum] = "b7ac321295bb89c7b62ec3f954c8ada6cf2148011427cea3d33b1ee55b0b37f1"
