# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3bd7b4e37e0cbf3c98aea9d97aee923"
SRC_URI[sha256sum] = "62cf6160c36044671c26a95c244c5f604ad8bd79cc820dfa949c10b5ea7fbede"
