# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de4f5bfeeee758f5a1d170d230fca223"
SRC_URI[sha256sum] = "cbc54a99d554a01e27324683a2c1db8e8ae123ea41fb817effe9a86a438dea2d"
