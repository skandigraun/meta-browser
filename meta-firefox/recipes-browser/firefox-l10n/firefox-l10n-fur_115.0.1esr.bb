# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "545f3ff395cefa947d311b3bd65a4c39"
SRC_URI[sha256sum] = "1edbdf5dcbdedf4b3cfff1e258f758bd90777eb3b67a9ce4226914432acf030e"
