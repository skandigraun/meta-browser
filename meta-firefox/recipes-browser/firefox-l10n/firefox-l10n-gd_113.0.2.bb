# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d65ececc59a9321a3e611f7a02bd6438"
SRC_URI[sha256sum] = "add022f533fd2f4a582f18a7df11bd68b240c416d9cad6337b66cbdd8936f6d1"
