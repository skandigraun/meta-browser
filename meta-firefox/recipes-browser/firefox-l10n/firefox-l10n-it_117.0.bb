# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c755688e13d526d7559c9930842b1f53"
SRC_URI[sha256sum] = "90de2be94175c26caf917eeee576aa47db173d33f0b62b56084a46c6ccd501dc"
