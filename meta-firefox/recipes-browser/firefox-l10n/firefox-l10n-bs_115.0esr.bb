# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d617aa48d8acf9df89d13ea0a5bfaf91"
SRC_URI[sha256sum] = "577f384f10ff61f3365dad3785e0422434bc3e8c5e46037e6535a495100ce65c"
