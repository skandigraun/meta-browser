# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ba7cac06657efb1f57c92f590722463"
SRC_URI[sha256sum] = "96509391a9c6140b5b6e784593fecd4639b4d4ffd474d79c9bab3c64489fd393"
