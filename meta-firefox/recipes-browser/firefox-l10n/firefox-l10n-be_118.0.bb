# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "368022ab310c7664f51a33ccac65b088"
SRC_URI[sha256sum] = "185b75e4a9bb23e355c7800eaf84b678b1b5bde855d3f0b3072737be144a31bc"
