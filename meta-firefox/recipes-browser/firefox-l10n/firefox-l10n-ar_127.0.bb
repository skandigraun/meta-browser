# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6878f6524f5942e98a61c8e032b5f1f0"
SRC_URI[sha256sum] = "cdc7bcd23481846f2080dcbff867f99131cc65c3ace40cdf0b6ae819f4fbc10f"
