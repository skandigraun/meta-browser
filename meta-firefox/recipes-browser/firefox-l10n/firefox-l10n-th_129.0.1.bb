# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9b23aaf63eac184f3d70071d511222a"
SRC_URI[sha256sum] = "9ee1d5c887f7247951ef8dcdd667cb751b883d1467061da753530f97a9ec6f57"
