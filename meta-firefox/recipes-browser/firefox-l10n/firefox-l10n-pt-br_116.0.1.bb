# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "979299a1ad010c52ff237b1aabc848b4"
SRC_URI[sha256sum] = "847d14c5f1c8a0e1345fe83449dc9539e0d6f6497964a65fbe3062c33a347643"
