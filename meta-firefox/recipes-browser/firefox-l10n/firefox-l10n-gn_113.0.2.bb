# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44f82da2481b31bd7bf3bc806bb5b7d5"
SRC_URI[sha256sum] = "47c9ca0005678586ce77eccbeed63b067819218e57345f0ecf84ef12b80dffac"
