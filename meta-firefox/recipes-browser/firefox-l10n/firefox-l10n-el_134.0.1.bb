# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ef32ecae67b8865e51b0d09ae6a8d9b"
SRC_URI[sha256sum] = "22585b5a94464abb69cfc3c453d35a3f87aad6541800dabc37063ca8206de04b"
