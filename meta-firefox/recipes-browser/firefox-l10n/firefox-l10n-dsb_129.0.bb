# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12c7d569e7e73e5395789ed3d8b1795b"
SRC_URI[sha256sum] = "7866767c338e5045afd6f8976b0580cbbb06a3ac33ae3b0195da13d8e5149dac"
