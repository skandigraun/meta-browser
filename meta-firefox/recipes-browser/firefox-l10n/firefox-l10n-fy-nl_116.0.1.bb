# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08701d747f27106ee4da0e7a1256d369"
SRC_URI[sha256sum] = "e913e37bdbae0f1bf969aebc64add8cf794555169d4844e02d0cc4e98370d6bc"
