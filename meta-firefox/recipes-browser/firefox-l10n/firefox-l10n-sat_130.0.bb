# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "413efc10bf464c34ae781752317ed010"
SRC_URI[sha256sum] = "f3e921d73eed5815473aba77787aca3d375b5163c38449e9effab21d48933751"
