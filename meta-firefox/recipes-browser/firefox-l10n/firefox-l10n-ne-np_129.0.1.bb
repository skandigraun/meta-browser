# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed0d254f92fbd420a070b3c9c6b808f9"
SRC_URI[sha256sum] = "95dff4db1a382456c4609f5debf7d7701b13dea3ed4410ffc36378e833278da9"
