# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "659365300f6a3c9eb7bd547434e92d75"
SRC_URI[sha256sum] = "fd73c177ea15b2ef00ccb0a67cf065a65a91abd7f142c0bcd78fcf9ba262530b"
