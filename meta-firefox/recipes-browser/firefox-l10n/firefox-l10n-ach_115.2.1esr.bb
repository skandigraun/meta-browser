# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ef69a9cdf1e7996a9bfe93316cd9c42"
SRC_URI[sha256sum] = "26f14692978c43c2f44f7476a1977957c7985d131d3945c89dbd0baf4a8a8377"
