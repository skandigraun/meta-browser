# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "891fb32e52a204d175cdcc5b2cbef2b7"
SRC_URI[sha256sum] = "6de3f58c19391a9394f67e97cd656d558ff1af973ff071622f0a39f7935afcfd"
