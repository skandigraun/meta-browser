# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7bdf27a761d77b96d358044d042b004"
SRC_URI[sha256sum] = "e3c05adc3167d85330eb021e106155e381f013fc1b9708a666306bf032f9fd0a"
