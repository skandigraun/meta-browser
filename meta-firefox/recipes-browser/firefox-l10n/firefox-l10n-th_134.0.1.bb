# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f51cc2c936c348870f847a351fe257c7"
SRC_URI[sha256sum] = "4fe24d5870a3ae0ad9f2f3594905f740b1cbc7de3a0a61df8b17530afde89859"
