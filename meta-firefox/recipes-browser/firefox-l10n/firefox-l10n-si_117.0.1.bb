# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4308f756eb248ed9d6e5ab17da04b292"
SRC_URI[sha256sum] = "547377841598d08fdc7c7430fe2bf6d6a2821c60bf409df9daa642564714ce41"
