# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "770323f00eabd12779404034d3bad207"
SRC_URI[sha256sum] = "5fdbf38758162d06070c6193eb0ad091b8eb84f0aafd31812a1ec030bf1ca9b9"
