# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d10e9c547718971a6e850769309c8844"
SRC_URI[sha256sum] = "9d50b0cc609dfe06f228412a47f057dcbc7f81835cb05662e4e4a568c807e10f"
