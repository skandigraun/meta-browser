# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "275f24fc4b0ac05c99fef4603dd880cb"
SRC_URI[sha256sum] = "b474686d3b54e00ef1c3606dc432c64a4f3b1f56321cc1b28cd0737e7e313ab8"
