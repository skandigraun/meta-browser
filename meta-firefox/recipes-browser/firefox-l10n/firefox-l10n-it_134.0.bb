# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2680c7e6a5f9e5f718b13eb297173c46"
SRC_URI[sha256sum] = "b654599d6cecd703e993e3c0c3b820a2924d7f3554ba7f4a64dfea1e4198103c"
