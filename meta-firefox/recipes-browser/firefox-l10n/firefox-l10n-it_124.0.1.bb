# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97eaa5b820ceb07859d04f8c652d3805"
SRC_URI[sha256sum] = "3917e54a8efa03a189b15695fecbd3fb70d87cc551bac67792c1eae002328c2b"
