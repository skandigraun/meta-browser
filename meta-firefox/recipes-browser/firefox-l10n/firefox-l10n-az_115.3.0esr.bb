# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb8f8b01ea90451e6e14c69aafa813bd"
SRC_URI[sha256sum] = "3b55378928edc7c3fdc08e8991483b727e776dd1db3bd231c9bc3c06b1ad3935"
