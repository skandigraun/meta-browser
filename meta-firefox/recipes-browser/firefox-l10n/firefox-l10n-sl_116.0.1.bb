# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61232d7ad198947d1602281e3fee2dbe"
SRC_URI[sha256sum] = "29286aef17e1a9c8f0d9f7888b580ce497d6da92124be07b87d6d553808bc3c5"
