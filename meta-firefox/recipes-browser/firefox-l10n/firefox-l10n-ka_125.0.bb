# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5f3a8fb31b1171133c58933965ef0e7"
SRC_URI[sha256sum] = "d3714a13430fd3989bccc261c24d0a9c51e745a7f1582500e08aef11af1353be"
