# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a61aa107eefa62ace082bfcf1a60647"
SRC_URI[sha256sum] = "31d944b632c82d40ab8a4928b7c53edf491e0a70408c79cfe7aa0bfaf52450ee"
