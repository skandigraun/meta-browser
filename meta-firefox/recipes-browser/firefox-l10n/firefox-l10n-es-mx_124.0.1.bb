# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccde4ed93c533804f5f58d73a7d2c6bb"
SRC_URI[sha256sum] = "7b31bbbf5ea0c572e37a4e87cd86c20b9d5dd95f8a75db08727c9529f9f7520b"
