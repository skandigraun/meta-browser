# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e7de0bbd2b0a2555646e7015c88fca1"
SRC_URI[sha256sum] = "b8438ad0ecd6bb4465eb1799ab51aed8aa046ede53a1764287f699fee761e941"
