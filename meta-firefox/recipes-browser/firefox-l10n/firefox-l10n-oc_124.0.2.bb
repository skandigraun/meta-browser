# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34d5509a124f8de8d7d311ded8e7368a"
SRC_URI[sha256sum] = "646d940a307886ad7308e7198f5afe78a2b7e0fdd927bc02abdbb6f454f73828"
