# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0ffbb34eda92ba1e99698045cc68569"
SRC_URI[sha256sum] = "ee77c4acf9c02e9cb84e875f5396df88539c670b3c588d48c98cd31ea7c3bb9b"
