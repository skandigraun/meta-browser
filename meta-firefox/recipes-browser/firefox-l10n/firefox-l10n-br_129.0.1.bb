# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "26a29a67ad6beb1f6a6a899e4f492c89"
SRC_URI[sha256sum] = "c48af941de36cb3b2ce2d6684173dc36bdf1ab125e2441c1ab5af78bea4b23e6"
