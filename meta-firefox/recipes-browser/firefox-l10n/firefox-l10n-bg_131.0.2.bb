# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8daf8bd261589ec6404bcb7f76be38b0"
SRC_URI[sha256sum] = "c697ef9f2878bb27404b86b2cb3a845e60a74f3d9cf8c804b63d2b8187dfa537"
