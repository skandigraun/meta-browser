# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ac2f1a53ab09932a2538ed4b080480c"
SRC_URI[sha256sum] = "9f35d9fac0c58b40011ca5bb2c7d2c050380d91cf2dea2fd301108304ca811ba"
