# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb108b3abe4dff7edf08728f1166af10"
SRC_URI[sha256sum] = "33ccdfc53507d645595ea95c1c0021a1d933c7bb6fefb6f8374c177c927bb357"
