# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0afd681a3066bb405a7c6a78877cc15"
SRC_URI[sha256sum] = "6f0b4aa984adfa7bac2dfb1823f3046110de962bf1dbc8a4b19eeb887c501106"
