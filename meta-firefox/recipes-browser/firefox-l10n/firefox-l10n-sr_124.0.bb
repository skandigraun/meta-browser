# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "775d3ad48019954a86796f64027e10aa"
SRC_URI[sha256sum] = "1a09274fa45860884d77952f98e97d5fd845963d5654ff114ab8dc760250a233"
