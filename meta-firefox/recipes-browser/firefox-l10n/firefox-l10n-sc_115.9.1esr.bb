# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf3d8f5c5000acc0c256082510d0a186"
SRC_URI[sha256sum] = "785f5891ddbf6975532397fc1c9c73c15cce9d558ea6233ff9026feae087e4ce"
