# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b23430dd36558764898d987d2c07b446"
SRC_URI[sha256sum] = "142bd336f66daf787ee616e357cc746391d7537e997cf9f1a36ae24c56654e99"
