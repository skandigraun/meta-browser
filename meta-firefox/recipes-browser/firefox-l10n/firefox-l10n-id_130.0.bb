# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "399423eccee250f698f04a7e54c37314"
SRC_URI[sha256sum] = "0f11e4f96b776b1169cae29ffd22ef8099fecb3d0f0daf31424277ea9dd5dcad"
