# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74862425b3a446387727497f28998efc"
SRC_URI[sha256sum] = "4f4c818c8959ae7ea4c73189aabe52011941e952258c0d87feba1a7c57fa8f77"
