# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc1d242865cf688a20ada3117d78f0e4"
SRC_URI[sha256sum] = "da16099068f0a6b605186fe487d9828576818f492c1b9e554051b82d39bc00fb"
