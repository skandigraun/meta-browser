# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b12cc786e9af84c3011689f456a97c7f"
SRC_URI[sha256sum] = "a03beffc092829fe06625cae62e0b9e9e946aeeb2d7d80244be4ea747ae45f13"
