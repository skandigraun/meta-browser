# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67462750bd3e7a10a7be0c1ed10cbc04"
SRC_URI[sha256sum] = "8a0a89153d4522718cdf43396dc81b1953c0b6dc3f997dc8408c84a687ee8a10"
