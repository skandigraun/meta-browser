# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbdba565dbbf377260546a8ace5f918e"
SRC_URI[sha256sum] = "ef6663d2e76d6e31d34a904ce8c130798130c5e378837c202f9f0c22a718f746"
