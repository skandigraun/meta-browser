# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f902f8c127a8824da1f131739f7c46e"
SRC_URI[sha256sum] = "4882e3f82b0095a9235355086d4c8a2a9b54875621dffc38d57b108975bc3c12"
