# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98ee04f03fbb5f1832fba2ed1c133843"
SRC_URI[sha256sum] = "f70fad075c4d38cf0f9b19d60441db613b8060309da8d943af78b6b0064ab45e"
