# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ca4911a40a8fe875d9c16ede53d3552"
SRC_URI[sha256sum] = "e87c2030d54806d4832c5407889693439b3ef06eb96c427f2bfb35ff26283a86"
