# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08e91f999d61112668d3719c050ae432"
SRC_URI[sha256sum] = "2523cc66399ed060211b157b3d68ad5146ba0c09a2064b90b50e34309c0965a0"
