# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7c8cab96571f566690d45c155fd8b1c"
SRC_URI[sha256sum] = "6c9b3225dce639875474ccc49ec349f1fbd03ab4a1456b4843a78a42bebd6c05"
