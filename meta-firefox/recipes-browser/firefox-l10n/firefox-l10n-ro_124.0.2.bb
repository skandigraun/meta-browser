# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41edb7f0cebb04118831345993928123"
SRC_URI[sha256sum] = "5b17bc760f730e2e092f176b61ca2f2f7239ff7705c1adfc01107183621d573e"
