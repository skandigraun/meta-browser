# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "412fda298ff4584291c43f360b438d8f"
SRC_URI[sha256sum] = "85421a38d162c4c4ae7cd3c764cee01ad5de157362415ad7e5af68e6d0921cf6"
