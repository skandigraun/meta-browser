# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48c42d6f7f92c72d48b6cad378a4373c"
SRC_URI[sha256sum] = "2053c2774c717e4dd9a7d4d0056d765bf225cdfc744a42eacb1f2c90823877b8"
