# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67759c17dd045b9310f8c8e1ef8ad25d"
SRC_URI[sha256sum] = "a1b87e573033739b8497be9be32baa80b06732f2ace23463deb028642692145c"
