# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "495c7101bc6262da94319f0d2c455532"
SRC_URI[sha256sum] = "acabfc72d5ead2f81da6850e6d2d52567f70972434484aa054e69198c7a9d578"
