# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53e07d4747f7dadd543281511d2d5395"
SRC_URI[sha256sum] = "7f6f51cc45674f07f905107d2b6ea1770c39ccf1b8a5782e6bab964fcccc39a2"
