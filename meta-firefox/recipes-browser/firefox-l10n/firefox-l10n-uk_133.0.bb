# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abdf2d1cdf3beb5b9be151c58150f025"
SRC_URI[sha256sum] = "89261fc9628e5dbc6ad4688e8ad37fd3d69b27f4fa04deacef6b5f1871947845"
