# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ce96040c0ff7a1da96b763a188c220d"
SRC_URI[sha256sum] = "9cac3edc38cdbd5a4fcd17da80ed03e4efb0f3b6c53735d8b723cede8607c0ce"
