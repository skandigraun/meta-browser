# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "511c7ace7aa91018fd4306ded505dbf8"
SRC_URI[sha256sum] = "752168e60f96d2b01275afc1ffcf7b8ad9f3383a05d6f99c76d7f8b2052189e9"
