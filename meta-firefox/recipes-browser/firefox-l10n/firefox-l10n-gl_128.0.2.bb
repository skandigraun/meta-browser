# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "362d7d528c7f70eaffcb4d9ecafd1094"
SRC_URI[sha256sum] = "1bb44ca1112cc64f1aa922db0beca78cb2f818311a302fbe46012979cf0be11f"
