# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1af319180dda226156cf381b85af24ef"
SRC_URI[sha256sum] = "4110f15664cb607808013fd67d1d2464de1cb68771950adef5b349c1e1c6c58e"
