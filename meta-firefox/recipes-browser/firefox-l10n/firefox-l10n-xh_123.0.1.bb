# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ada4e279db6fc781284c9f5e11bdcfd"
SRC_URI[sha256sum] = "93b1b39f80943aeed0129812f5b459e223bd0887625c5803d9c90f4ce5785daa"
