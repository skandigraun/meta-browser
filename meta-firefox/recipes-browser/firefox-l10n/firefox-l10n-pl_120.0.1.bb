# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25dd622b16c4f88ccf3eb62ccb2d7462"
SRC_URI[sha256sum] = "c8e123e6eba21c417cb2bf1297a90313523f72d18e493e3cf47b5826402b4ad9"
