# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67af267d240f69099fe6b097a8860b3c"
SRC_URI[sha256sum] = "452ab26c5c6d0eea6dfb71e07f32b5751ec4591cb0a7f84c4c626f05c0882762"
