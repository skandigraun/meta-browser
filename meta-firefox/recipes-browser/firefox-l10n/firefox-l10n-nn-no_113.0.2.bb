# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08be77ed09bf2485d785e24506b1827f"
SRC_URI[sha256sum] = "8657313c1245d1dc852db19b5d5d451d3426c5ee8278076feaeff80c10a0f442"
