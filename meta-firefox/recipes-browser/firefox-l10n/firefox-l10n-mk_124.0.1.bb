# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec5fb2a49714ddac6271bb310193920d"
SRC_URI[sha256sum] = "e44e17ffa7f5cee93ddc11049502f4db0dbcf4e619453b72d654ce9e20dd2272"
