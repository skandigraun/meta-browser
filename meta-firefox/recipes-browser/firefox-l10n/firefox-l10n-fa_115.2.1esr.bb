# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fc90886f3a44e45b6dceecd8b545b84"
SRC_URI[sha256sum] = "286588ebe47d89ed4262de71365017079c57b35121a2c3ea2fda9a50909aaa3b"
