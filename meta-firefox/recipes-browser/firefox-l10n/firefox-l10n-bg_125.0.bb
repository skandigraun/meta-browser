# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90f4d592c73390c2276c5e10cdd9396a"
SRC_URI[sha256sum] = "d41bbd5a0cac6a5f54fe79c9a8b4b344571d631dd3e756106097af0be854d9fc"
