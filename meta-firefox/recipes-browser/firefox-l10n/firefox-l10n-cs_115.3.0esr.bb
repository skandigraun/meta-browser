# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2a18fa6c46d2958c32731ad865cafd2"
SRC_URI[sha256sum] = "44ea7cc243fa961b4f5dce217e1274b344e2f80024b73415c93dc64d37ab2d49"
