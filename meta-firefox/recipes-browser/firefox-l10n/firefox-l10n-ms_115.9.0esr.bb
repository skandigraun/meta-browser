# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4722625c8d1e5604bd02865c9165d120"
SRC_URI[sha256sum] = "e5df88a593c37c49c9c30c35c3d430fd78f0f733fa77ae771ba2725337ee826b"
