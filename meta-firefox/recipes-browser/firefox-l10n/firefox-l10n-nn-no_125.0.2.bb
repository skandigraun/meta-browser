# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74d4712710724f9c82d928dd47725238"
SRC_URI[sha256sum] = "96da6a0f0b5eaa1a3dd429fc215732a779dbf1881fec95f90470fd1e6e350fdb"
