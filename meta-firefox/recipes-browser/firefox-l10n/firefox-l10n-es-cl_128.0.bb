# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f86c1228c8f873bed111b22f6ca704e"
SRC_URI[sha256sum] = "10f4214df852bbb9b343becd19d9db9fdb6299b0cdf9f8a7adec4a8871edf2c5"
