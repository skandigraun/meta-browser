# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6593d497c057983f42a6c020eefd3a5b"
SRC_URI[sha256sum] = "91b41a1431cdc31ac38c121af6332df4eb4c034cb78efb4c2b46448c53d55f0c"
