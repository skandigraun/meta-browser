# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f3b911b7c74f9acda81a80d195f5ba"
SRC_URI[sha256sum] = "e157ecd63b74896f9d29e87909285a3998e9835a449d03c058506ad50c260cdf"
