# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "035bcd696f868e6222a72c2612d13912"
SRC_URI[sha256sum] = "0c9a67c6f934321212b613d9385373fbe649166005217edb42d3d9fede07feba"
