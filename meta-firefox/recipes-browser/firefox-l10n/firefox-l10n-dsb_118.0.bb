# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e1418a58fb95a19a67e30b3a2235462"
SRC_URI[sha256sum] = "46c9fb3dd3f7863d4dc80e23f0e8d01802734e41ffd82a961464478f29a0cede"
