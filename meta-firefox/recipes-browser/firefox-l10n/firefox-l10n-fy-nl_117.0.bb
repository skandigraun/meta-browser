# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b11b814010530fbfae9bd8310d4e4d8"
SRC_URI[sha256sum] = "b4434a9a93697f1f1a72b93c017df00fc6e9da9141e438db8ad23a9dc9a7c050"
