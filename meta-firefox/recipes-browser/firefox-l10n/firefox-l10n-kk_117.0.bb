# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da9b0de68e0b0676ee98c80a28b5bcf9"
SRC_URI[sha256sum] = "9e16bf75a33498201d82fabbde88fc4ba3a65a6d006877c9c9772011c7126c69"
