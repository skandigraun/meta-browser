# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5965cb254ee5c030296d3734f0fbefbe"
SRC_URI[sha256sum] = "a8a5094d4467158967f3a925455007eb8592f5c7965f02e8f42a8026c6a6d9a9"
