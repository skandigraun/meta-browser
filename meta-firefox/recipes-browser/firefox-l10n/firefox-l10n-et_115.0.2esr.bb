# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd3ccb6a7e70469b99eb87e61568f063"
SRC_URI[sha256sum] = "f86a1cee6c6267280f8ceff79cd4b32144f164addc37f327e7cdf3037fa63616"
