# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28a7fa76b27d0bf61e3ad95de254110b"
SRC_URI[sha256sum] = "f3ae3f254568a79e96aa6ab5547abe4660fd7a0b1b97a76deebdf1a29b07033c"
