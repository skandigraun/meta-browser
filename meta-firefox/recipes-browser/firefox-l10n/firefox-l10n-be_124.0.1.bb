# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6660f02400a8d851bdb31aa20dbc862f"
SRC_URI[sha256sum] = "fd83bda0570ee23ff8ba4264817d25d96a3ebd905a6c945c05427e984d1b1c42"
