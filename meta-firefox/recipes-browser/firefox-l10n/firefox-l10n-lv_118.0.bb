# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3133881f6e7876988ceb65bbfe4ac603"
SRC_URI[sha256sum] = "525fc4fa3d3c9bd63f72aa015cd79bc23ce66af0f7d1e89868c9ca195682e34a"
