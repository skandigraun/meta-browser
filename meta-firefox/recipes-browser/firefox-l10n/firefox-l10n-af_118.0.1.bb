# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4fc2952329e0dbb4dfc9b6bfb58865a"
SRC_URI[sha256sum] = "c3573e094494933ab862f1e79de589cefe060ba981073cbe61640a5acbc7f52e"
