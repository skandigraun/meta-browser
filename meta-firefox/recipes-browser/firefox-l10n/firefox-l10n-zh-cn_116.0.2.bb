# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81d117cb36512a8bfea40a988b941fbb"
SRC_URI[sha256sum] = "1f68563060ed83ceefb2ce10693e4663b8e0c080cf6ddc93d2103b42ffc956a9"
