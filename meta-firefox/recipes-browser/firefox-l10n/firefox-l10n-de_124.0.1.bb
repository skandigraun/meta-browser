# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6d5a508763bdfaa4c7d32f8611469af"
SRC_URI[sha256sum] = "e1c13bfee968fa86b4f07c5a0d37fc04afa8997cda7bed178d1203ca319526dc"
