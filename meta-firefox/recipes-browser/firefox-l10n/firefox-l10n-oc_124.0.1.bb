# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6cb1b693f9f9fb78a65dad48aa40882"
SRC_URI[sha256sum] = "f885cea26604f919bb83a8bc3358687d47d198f9f28606454b0caf3a560bf047"
