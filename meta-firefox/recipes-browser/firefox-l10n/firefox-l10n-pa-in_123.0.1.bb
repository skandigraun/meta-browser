# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ef343a86daefc40e6ea3f42fa42b559"
SRC_URI[sha256sum] = "7e011099dcbfc3133101833ff33eefd9dd8860fbc90c6e1408dd3e58e7b906c9"
