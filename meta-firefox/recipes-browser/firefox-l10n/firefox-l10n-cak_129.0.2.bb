# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "398ff12dddb85e86947c48c610947cd5"
SRC_URI[sha256sum] = "47e804135a5f3676b10ce1a40a761d81ac8cba59e7e24b8b2c4aa17ba8a5f0aa"
