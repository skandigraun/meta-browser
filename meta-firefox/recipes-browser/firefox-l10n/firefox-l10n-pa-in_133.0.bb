# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1047a180bcb1ab69606ac47801db43a"
SRC_URI[sha256sum] = "6ee2e9cb3b7a30175309cf4cc1bfb6c3ad6bd567d2e5ed27fb6c0b95bac954c0"
