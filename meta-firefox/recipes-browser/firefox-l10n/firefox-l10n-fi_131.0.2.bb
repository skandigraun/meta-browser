# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1132c652bc3ac74ddb8d346023f80b00"
SRC_URI[sha256sum] = "7071e6b75415e1a5cac5438034e8a347a903750cf9a0ac54b756291f419c491b"
