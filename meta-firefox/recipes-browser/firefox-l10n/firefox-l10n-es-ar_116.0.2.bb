# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9bef853d3064b1518bf03d2f8ae0f70"
SRC_URI[sha256sum] = "8e0fb486c4943eaa12deb2c66013626d930426de0e49093748b13e85de75425b"
