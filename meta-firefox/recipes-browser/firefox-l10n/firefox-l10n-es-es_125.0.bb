# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0cfb808c139ecd2e0ac100e92f07eb4a"
SRC_URI[sha256sum] = "a666a2ec2a75696e60a9fda6f2a8a108132e1079ab9fe86048a78471caf92dba"
