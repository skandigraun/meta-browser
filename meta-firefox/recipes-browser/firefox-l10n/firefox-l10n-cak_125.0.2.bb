# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aeb60274273339f5c647d0316cdfa49d"
SRC_URI[sha256sum] = "594575cfd4bf08bd4565f8ea45fd7a60412680d33346eb9127f2c32bd734613f"
