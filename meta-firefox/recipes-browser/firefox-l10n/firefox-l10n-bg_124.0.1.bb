# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbea0078cf3d2fb4737fa9838329e612"
SRC_URI[sha256sum] = "7c39f4aaeba5f66be5880063bad9c26b7601d0369ba3002728bb9304f848affa"
