# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d766347a26c68b422fb78b153e5c9b7a"
SRC_URI[sha256sum] = "b333321ce6575fdaa6dd8ed655bf8cddfae95172ad06c6cc7ac616f6f16673ae"
