# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8b181610b51edb1e1f7aff8218d205a"
SRC_URI[sha256sum] = "908dc0db9cd7711a244e34064305738ac81a5357f442bb0840e1c389d1984629"
