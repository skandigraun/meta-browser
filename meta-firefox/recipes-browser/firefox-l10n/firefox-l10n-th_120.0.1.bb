# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cb2479f9b4195c86968f6126676355a"
SRC_URI[sha256sum] = "a7aeb2436652bb4f2546b698a3f830837b495439a64c7c8140055dddbef37f15"
