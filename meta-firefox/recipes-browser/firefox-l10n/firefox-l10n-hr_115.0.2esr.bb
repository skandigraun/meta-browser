# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfaf8212d0aa2b0cfcd34f7ced0d6bf3"
SRC_URI[sha256sum] = "0a89bc81af20e0a45dd3dabf73436022e457a970cb3263e2ef20912b67856eec"
