# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b72c3b74bb1b22416de1ec4eed5f211f"
SRC_URI[sha256sum] = "fd6601f0be1c00f8f29800854e0d2f2428b0a0c8d2e254aee5a2ecbf6dd2714d"
