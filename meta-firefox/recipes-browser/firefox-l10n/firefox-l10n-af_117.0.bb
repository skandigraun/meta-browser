# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "222e9315a5391c8f06f7198f42d98da2"
SRC_URI[sha256sum] = "f380f222303e47004eefc0d372ade5a8a7db2548ebe9649497d9c9de06497fcf"
