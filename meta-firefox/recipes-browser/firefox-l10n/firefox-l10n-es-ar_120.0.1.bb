# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef2d9b8906c6f2ef4e09cd9b8d629e01"
SRC_URI[sha256sum] = "dee2f0c0f1c66f3f192af360842bcee2790cb0d389bddbb51c70f4b0dce19cb4"
