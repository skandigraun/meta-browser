# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edf2e957e3c0ba95b5e7d1d30537bc80"
SRC_URI[sha256sum] = "fb3cbc75a0b7c391b0c6c04c73029542c6ba39c744b2c754056d5c149cc85370"
