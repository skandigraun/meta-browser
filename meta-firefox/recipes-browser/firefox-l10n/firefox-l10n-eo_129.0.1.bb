# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "640e75f2084d5a50a50b2d1971707417"
SRC_URI[sha256sum] = "f4343ae6dab1bfa8fcc71a149d5da4bf079a754dee68ef0c691a7c752b1f464f"
