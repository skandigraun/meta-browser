# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0358f5af1cfe499de768585a4edbf694"
SRC_URI[sha256sum] = "30e26e599e8d90f83c898456032c7062e5fe89a50233e5ee7f74d9251ead6887"
