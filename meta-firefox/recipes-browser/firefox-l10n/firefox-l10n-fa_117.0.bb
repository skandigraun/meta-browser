# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "560d251d689dafc5f2a9e49e9a272982"
SRC_URI[sha256sum] = "4ee67bc5d510ed401b5e402cbc8362566092c86e1507cbd4ab4a4939b0bf482b"
