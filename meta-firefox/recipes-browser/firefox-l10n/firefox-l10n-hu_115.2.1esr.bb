# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d8b2eb6fb03b0f4cc54f15bf4efd690"
SRC_URI[sha256sum] = "8ac73cf93854ac739868e53a68da747ef5035066e0762f786ac430e56ff47463"
