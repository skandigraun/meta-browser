# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eeebd8b4080d7820a46efed8bb7e955c"
SRC_URI[sha256sum] = "6957410658bac2115760be230a9eb7aea7fe250a679c2014864a5cbacd9fd34c"
