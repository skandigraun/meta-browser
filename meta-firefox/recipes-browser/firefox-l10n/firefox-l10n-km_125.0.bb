# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7f43843b6c4ff96100039ea3836f453"
SRC_URI[sha256sum] = "f4f374d8cf9087f23986cb1b31ee1178fda3f1dba55bc147d7bcaa27824d8e13"
