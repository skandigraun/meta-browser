# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9510ed980c724ad811592e4cacbf8211"
SRC_URI[sha256sum] = "a3bf05ab834c39504932e456f5a6b9ffa626cdaaa8fc0ce1018bad720e203cd3"
