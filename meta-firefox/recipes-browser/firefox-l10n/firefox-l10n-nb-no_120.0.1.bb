# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f39dd28e2c0804282ab1f51c1873d7d3"
SRC_URI[sha256sum] = "b471fe1e05e4cd6692240a5a5bee4caf1816eb0e8907243d9d6cd163c66851bf"
