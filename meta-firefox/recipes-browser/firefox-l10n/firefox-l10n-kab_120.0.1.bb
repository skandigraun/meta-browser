# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c24bcfb40f9985ff83f518b9bf269082"
SRC_URI[sha256sum] = "0813c0e7dd6e7d090e6006dd4ac993f8f772c5668ee55d4e06cb3b30dec2b19e"
