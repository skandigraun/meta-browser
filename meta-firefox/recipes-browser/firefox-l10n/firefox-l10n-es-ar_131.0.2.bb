# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed980764db02ca4d94b6d245ef32f4d3"
SRC_URI[sha256sum] = "91fc24b9ca533d044b95edfc7a9c517ef78844825d9b352de506ff2a048a88c4"
