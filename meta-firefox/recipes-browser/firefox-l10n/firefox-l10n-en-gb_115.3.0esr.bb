# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d62846aed4b065b53aad2269f4522ab8"
SRC_URI[sha256sum] = "b75e3afe513ac6df4d5dd259355a8d4c3bed6e03c8c7e5f2ce8e366cd194c382"
