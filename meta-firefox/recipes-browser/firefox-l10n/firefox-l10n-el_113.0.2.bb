# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cc52805dc01d631fa7416dff9f40cec"
SRC_URI[sha256sum] = "9fb9ec95b5ff78c34ba92fca9e3309ebce6e948dc9a68ac0e2c5b07938ee4ab9"
