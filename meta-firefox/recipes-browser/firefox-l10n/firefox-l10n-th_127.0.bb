# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba29914e889d7eab00395fb0e2b35e93"
SRC_URI[sha256sum] = "7d3ef3c2fa956ee4e8fb740e74403e8e6b81d061c12f5f8c3734dbe1cc5ac433"
