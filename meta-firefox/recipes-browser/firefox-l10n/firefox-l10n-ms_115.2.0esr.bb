# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9736facab068414fba5ccea268de3668"
SRC_URI[sha256sum] = "be2587944912631006c879126962fc66730e97d2e60b2247e00670d3e0c1b3ba"
