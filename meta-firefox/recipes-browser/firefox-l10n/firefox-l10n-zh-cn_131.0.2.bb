# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f1af871c574b9b83e248b7ec25b73be"
SRC_URI[sha256sum] = "6042a22a7d2ae23962603ec9183039200c09ef6cb7338cef18fc81d79a767d40"
