# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e1a33e25722a9ceec3a338db318c5ce"
SRC_URI[sha256sum] = "f3870238b118fec6f55bdc7c38464642173c37c75485f5f6223d92ea2ed7f451"
