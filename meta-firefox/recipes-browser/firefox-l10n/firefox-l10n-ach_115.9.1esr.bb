# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aeb1992ca6d850dcabced64873a284e"
SRC_URI[sha256sum] = "f84fd6c39551f64c93fa5cb1c82f6c9ed9ce7b598ee63f6d4249a0f93f62a53f"
