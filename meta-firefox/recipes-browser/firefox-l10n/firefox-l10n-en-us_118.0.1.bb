# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df69b53ee3d86ec9865bc4a543ef7fab"
SRC_URI[sha256sum] = "672cd889ae8b26276fe89b6ddaa2de7fe8aa3c7ecfc3c2d75cbbf0e5c43fd77d"
