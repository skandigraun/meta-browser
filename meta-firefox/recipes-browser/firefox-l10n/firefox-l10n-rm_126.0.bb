# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c41ef8b7b298ead92b549c776981334"
SRC_URI[sha256sum] = "8e2b385ff1108c3a7de60e42edda84d80589c1f32b63f40b5b051e4b002413c6"
