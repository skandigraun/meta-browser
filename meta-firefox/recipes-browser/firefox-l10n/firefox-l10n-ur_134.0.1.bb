# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c934a025e91241d4e08f0425014652f8"
SRC_URI[sha256sum] = "669719723f30b2af5f82af3650ba5b38730b58a893d6777662efdca1aff6793b"
