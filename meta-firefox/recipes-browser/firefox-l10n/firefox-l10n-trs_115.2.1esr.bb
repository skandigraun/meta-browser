# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f9dc1c90c64c6d2ba464a4d0070bca6"
SRC_URI[sha256sum] = "5df8703db8ccdc0056b7f9bf4174e0d4c43ac6e1079f7097cd2fca44c9c8f84c"
