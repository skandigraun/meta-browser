# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57005d13c66b1792cb0c9a96d1b5a6e2"
SRC_URI[sha256sum] = "ca6848c00b8eb63af18af8ff994353c4a141691b2430062ea767937426f9842c"
