# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2d13e5ab6549488642133649f555e0e"
SRC_URI[sha256sum] = "2ec196022d85589b0bc74c9edf348ab9078854fbb84ede90b76144681459506f"
