# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9fe03537dd92a3a193f591cbba69240"
SRC_URI[sha256sum] = "5077c2573ba4a0902f90c92d8d207d2161ac6aeae5b6bfaa8d9a08f84c05cff7"
