# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c72c4e1af143b86b6026798e7eb78fd7"
SRC_URI[sha256sum] = "45c5f7892af70afbac3c31360890f1236476551a6b69a3151a296e9677050240"
