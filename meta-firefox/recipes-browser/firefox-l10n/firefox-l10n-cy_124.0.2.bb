# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c9a4ee3aadd112cdfcc6099c1238a27"
SRC_URI[sha256sum] = "71f34b38d4831b34b74201354ce40c1f4ac06080511a6ba11f754edbfea85d2d"
