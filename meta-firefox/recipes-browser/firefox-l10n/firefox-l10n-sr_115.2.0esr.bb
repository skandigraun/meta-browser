# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffc5dbd623467fa457752b50cb34ac2d"
SRC_URI[sha256sum] = "04aa23a6482f887c21f6aba692f889c6d19a4ca4bc99994a2c47b6f18ef0f011"
