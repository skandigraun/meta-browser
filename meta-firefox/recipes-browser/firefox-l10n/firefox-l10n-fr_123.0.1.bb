# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acbf7c63c2785a64fe0a58cd0d83b8b4"
SRC_URI[sha256sum] = "f590c8a6de8a984ac02d0851f2a7db9a7969471ef3ecd7b850945c8202c8d8ec"
