# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "151489743d74c94501e06e454633b26e"
SRC_URI[sha256sum] = "bf8d805bc4e82b654672bfe50a7710a52db3101e633475cf34c4265a0a16aa83"
