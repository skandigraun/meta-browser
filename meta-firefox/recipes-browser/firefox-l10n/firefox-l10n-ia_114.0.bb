# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3c6ab512c2a348f78be48d300029910"
SRC_URI[sha256sum] = "1644d3bfd7e4c2b537a7a52b25b7f9cd808ddbaf86e026be91536c62252cd792"
