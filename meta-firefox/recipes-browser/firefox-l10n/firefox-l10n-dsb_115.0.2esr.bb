# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "118fb5e0acec569c8146d9756c51a71c"
SRC_URI[sha256sum] = "3b7758c53b19c2cd2fe02701c2dafe333588bff510e9a672f013665de33b0cd6"
