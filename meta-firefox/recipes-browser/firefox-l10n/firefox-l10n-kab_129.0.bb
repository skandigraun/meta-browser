# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6bb45f7ffc5962c2ba81e8eeeb50822"
SRC_URI[sha256sum] = "23bb21b1bdf6aebdbdf73cd39c2128fc684b5a4917ce3337a2f5a99ff925a6b0"
