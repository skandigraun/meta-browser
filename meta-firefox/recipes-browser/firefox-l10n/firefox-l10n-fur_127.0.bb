# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "427b91f3466996bec3fd8b7067c2c237"
SRC_URI[sha256sum] = "2a7b26cb904b305bc691840072ef31db1fa4161006e41decd71aaa8b27b41ca6"
