# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5984db077fc064d0ca45ab6064424a"
SRC_URI[sha256sum] = "ee2c7bbcae5dec4d00f3b76aa30a8d85ff432979ae22730877d4abedfedc294c"
