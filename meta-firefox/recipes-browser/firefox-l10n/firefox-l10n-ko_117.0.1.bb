# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7a0bcfb5ee1b6c1a2dc859929c78e1b"
SRC_URI[sha256sum] = "a4c8adb4d52eb79cc8f986bc0680b79835c9a5a6994e6b7030b45ec5482d7902"
