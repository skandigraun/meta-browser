# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2b6d0b1f46bce7064fdb0ba56a8f45c"
SRC_URI[sha256sum] = "2e796e4ab26e1e22683b9919efd25573d8fd738379a0f612f61220eb31541f3b"
