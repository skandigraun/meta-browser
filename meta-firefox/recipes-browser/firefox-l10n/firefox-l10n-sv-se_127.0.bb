# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "990c827f9f579450be0a874b5373a6dc"
SRC_URI[sha256sum] = "8e9a39d6faf2aabd6be4bab1cbacc82c2f2b340806f9528774c087accdcac285"
