# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c284cb7eb9fb7f0d64320a9e15e86bd"
SRC_URI[sha256sum] = "97948462c0cec136dd0027c9dc1c9802f6581d05c467f6fb593d71c7e020f7d7"
