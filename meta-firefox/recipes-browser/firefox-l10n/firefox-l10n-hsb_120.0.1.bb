# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bdf0e56a1774950c1a772357a96103b"
SRC_URI[sha256sum] = "1a25d0e825be4f36d7946778fa57952cde5488b0b1edc0b8329d4ff6236efe92"
