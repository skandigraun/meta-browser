# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c481af42cb5bfea25f9a9f63bfa65ab2"
SRC_URI[sha256sum] = "02c2a417c5d307d054bfe4e5e09d4bbb3d029753e75b6c2605bbdf580248cd9b"
