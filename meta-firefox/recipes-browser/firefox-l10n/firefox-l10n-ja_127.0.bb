# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a8b95386ff7354870767633b6a835c"
SRC_URI[sha256sum] = "476532c28c3f6ce15c38844d16d8a71685ec495868905b83882d4907688d5c8c"
