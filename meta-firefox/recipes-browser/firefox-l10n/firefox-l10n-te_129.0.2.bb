# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bc09981791f59a7c7b94450ad08b81d"
SRC_URI[sha256sum] = "a75cb709390723d29d022e258a5cd02651288aad55b343b45ac6165227f35952"
