# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b7321450d79dc1e771af6e3513668b"
SRC_URI[sha256sum] = "4a04e9518c8ef6eb812646bb0f8e4e46e35c3d804ffcf7ea649011217d2aac81"
