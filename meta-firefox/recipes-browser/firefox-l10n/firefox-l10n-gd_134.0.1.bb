# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86fff14989d6813f865f4fe07d119223"
SRC_URI[sha256sum] = "2c43e3501c2f103189498f9badf21cc417399e0b0f33cae347aa030e8a4bfd55"
