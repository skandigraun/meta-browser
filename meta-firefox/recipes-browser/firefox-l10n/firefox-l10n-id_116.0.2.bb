# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edff42040581a03fe580682bc3d5d23c"
SRC_URI[sha256sum] = "0775cf6bb4cd200492c4a8ee1d5ab563d9a465809adaa07b0604355b018ecf11"
