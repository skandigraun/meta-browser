# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eeb49482f26798bacecad5b90c3e509"
SRC_URI[sha256sum] = "718493669a79d45e80e5c1e01fa094075dc74ca6c347e792b169b909da5c9310"
