# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7af574f00530c0973287809e6e55496b"
SRC_URI[sha256sum] = "22534e9120472058782749d4246cee6f8775a1bf1a0fb7a5ae2ee2371ba78a43"
