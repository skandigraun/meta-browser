# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4728db90fa538c7a1c4b41137c8efecf"
SRC_URI[sha256sum] = "625c2e19caa24046e624383501a395bdbbbf39594e742cc40e31d85cdc3eadce"
