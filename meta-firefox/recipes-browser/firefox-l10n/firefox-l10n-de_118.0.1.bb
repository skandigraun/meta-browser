# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2cbaf4e45560ee9c77a4040503edcb2"
SRC_URI[sha256sum] = "99ff3f3e8746c4c9a31854219986570f4d9de5b1a11e27260300af232cbf04cc"
