# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2a7c29d901eead9296bd85a468a2970"
SRC_URI[sha256sum] = "38109a7439b2781e2d7e0c3e926bb86bcaee03150d39151fbcc2e00cc254150f"
