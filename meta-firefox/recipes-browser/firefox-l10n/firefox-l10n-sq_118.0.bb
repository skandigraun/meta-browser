# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dcc066407c59b896621848c40891887"
SRC_URI[sha256sum] = "2b2e59c8ae9104d7ae8334df175090d376c15b91884fb1587c6709bd2a4d5ba3"
