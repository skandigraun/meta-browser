# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d08dd63f68cf6a0dc34d5003b89cfc7"
SRC_URI[sha256sum] = "e51d915ab71ec21792401faa59de0db44b28570cb7b3e089707479c454428fd4"
