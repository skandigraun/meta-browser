# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba7cf3b449a36f01cb3b2c8bc6fcca6d"
SRC_URI[sha256sum] = "82b25d22b44978db94f6db6458fa38dbd6ec83f2e4c60f713df7fa46346843b2"
