# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d0e1a6670c4e908290757dc13fbb472"
SRC_URI[sha256sum] = "006ab901a085f11384caef92da4f82b1c2aa5b147b2dc331bed4fcdf708056bc"
