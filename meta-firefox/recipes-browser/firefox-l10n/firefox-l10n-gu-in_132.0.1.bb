# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b804e1f6a8aebc9f964c7e562d953259"
SRC_URI[sha256sum] = "40c5c35f815da1ea14a2c23ce5ac1080320bc8855409d0910f30c8bc0f498d75"
