# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "465cd9a60a6cc169a01ac6f78bd58c81"
SRC_URI[sha256sum] = "c41a476f0e7c5c039434e93886ebf541edd58997732b504989255a1b00311623"
