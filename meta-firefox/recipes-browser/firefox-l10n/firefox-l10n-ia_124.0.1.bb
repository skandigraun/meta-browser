# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a0a910896979ccead5d9a6f24d8beb"
SRC_URI[sha256sum] = "b45cdc763c05e9b802a0ac477356c9076cbc459f763ddf5be37563a492e635bd"
