# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13c575a5534598e85f2f14948d925955"
SRC_URI[sha256sum] = "c4cff35a9ace9d9b57494a7d4fdfab50573f0e09835de1bbda8296d6452a921b"
