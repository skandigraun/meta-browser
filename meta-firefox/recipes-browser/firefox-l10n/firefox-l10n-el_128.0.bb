# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54a1e861480ce7978b52cc4b5789c2f9"
SRC_URI[sha256sum] = "649bf3f8e51de955ee179464dc49b703abbb4c44791913fbf3aa35506f670c58"
