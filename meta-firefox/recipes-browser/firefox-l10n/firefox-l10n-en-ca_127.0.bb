# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a87aa12686227240d8a82eddde519d7f"
SRC_URI[sha256sum] = "af06f23366338f57489c3b7e4aedc03a9acb20741d7b3fb19b36643eece15697"
