# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2239012e84a043fba833d7439381b10d"
SRC_URI[sha256sum] = "dc17cb4fcd6ffb39e0ad9f8cbfd05d6e667baaac92606eee7f830ec2888d09ac"
