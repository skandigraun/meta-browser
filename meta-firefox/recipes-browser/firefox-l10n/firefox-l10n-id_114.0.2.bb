# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e6363cb9834848d491fd26e8d71bac3"
SRC_URI[sha256sum] = "7e2186f557295d48741fa77f0c6476d0a1e56315338179592201abd44d280206"
