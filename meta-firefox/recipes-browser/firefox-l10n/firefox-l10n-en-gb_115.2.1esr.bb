# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa0d70614b13f09388aa3dc2e44a0e71"
SRC_URI[sha256sum] = "10dcc8f6267ad0fa5da1a09a506568ee55e63c0e2c68e67f0aa3b706360f1270"
