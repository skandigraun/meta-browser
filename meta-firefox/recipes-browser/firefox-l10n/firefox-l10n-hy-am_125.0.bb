# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a26e5d00f937e8db3f0372988a25fcf"
SRC_URI[sha256sum] = "292e128c28ebfe80801e4f01bfadbb438f12056ae9252ea54dae109da5c13e31"
