# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "922dc64e9c2bab681d06b85f766c88db"
SRC_URI[sha256sum] = "8e05c8885bc7b23f2c6fd29848e382457c58e3c61384c7e8093292dec8abfd8a"
