# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb5220af427586805a32957e64cc8784"
SRC_URI[sha256sum] = "8b1e99aa6d489ef87b8084c7d6712e148010dfb54b0dafb1448504a22fea88a8"
