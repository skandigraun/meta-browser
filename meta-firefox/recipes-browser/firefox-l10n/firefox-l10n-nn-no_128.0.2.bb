# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9486d3b8a9c0371258ab32552208b4eb"
SRC_URI[sha256sum] = "8665c43b3e75f4dd6d7f795ee3fb6d00530febb7d62fe11d74a53fe7f9bf1173"
