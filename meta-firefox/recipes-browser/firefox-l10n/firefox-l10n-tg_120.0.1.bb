# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66d5848fca8cd3b0df0ded07aefc48c6"
SRC_URI[sha256sum] = "12b1e7f6b74d861a09aee01f6db0ee8965afa0638cf981f3dc7f1b7c9e72bba6"
