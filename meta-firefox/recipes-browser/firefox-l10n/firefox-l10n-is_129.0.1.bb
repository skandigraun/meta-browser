# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11bf71501256603973fb964a7bd8ce72"
SRC_URI[sha256sum] = "7c526d45d34fda05062ae59572c09c3cec63e0443cd562b7380219b5a16420ac"
