# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "589a55d88501db83b4d7937c06e1379b"
SRC_URI[sha256sum] = "337aa181304f96943724bcd1cbed3f6cb1b6962b8a3a997631480d9ebb51f313"
