# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a215ec5e4de53e9fcdf2f773249d7bbf"
SRC_URI[sha256sum] = "84adcf003f34834758e862783ad9ee4a4399ba548bc5a889fd65dd84425cb5e0"
