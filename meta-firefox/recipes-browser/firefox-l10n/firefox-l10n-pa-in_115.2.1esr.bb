# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98327d5a5d5197747342608fb10c2a3e"
SRC_URI[sha256sum] = "027fe18587117f70192a68539ea9747b9d466a44e5faa246d571db0bcfb034eb"
