# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd4a050d105bb89036e4d0737b43a170"
SRC_URI[sha256sum] = "982894a389ac48df6181c51509b5af1ae4b26e97341426226cf57c3daa0de4e1"
