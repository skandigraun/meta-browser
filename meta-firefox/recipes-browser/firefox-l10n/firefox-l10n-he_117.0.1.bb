# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8649ea1e73561b9f7524b3f61c989d3"
SRC_URI[sha256sum] = "6ca3820090321982f392566afc252b00c131cc78b062442119efd693c5a26ecb"
