# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e1ff7af7dc44b2fa190334642e2e743"
SRC_URI[sha256sum] = "2df3dc141b0116685d28325576597c06f0d6a6ee7d5cd3a8db2f76a0cd8b3b9b"
