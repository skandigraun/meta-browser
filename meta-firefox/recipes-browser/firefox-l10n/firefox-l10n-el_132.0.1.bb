# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a47b7121ee8c6c56b848b2688e5ef52"
SRC_URI[sha256sum] = "289c99706204cc682dc10b959677acc059e7c78ade46d1349e3ff10da5f00ab6"
