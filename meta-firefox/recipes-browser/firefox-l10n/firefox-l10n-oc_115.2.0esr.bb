# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a147651bb96a64b1d88c361674bd32f9"
SRC_URI[sha256sum] = "b01b6bb7286d26d24328ebc6f576425974f06eee2504cbdc47979680588229bc"
