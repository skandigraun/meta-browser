# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16f689caebf4440a7ab076cf78e34cbb"
SRC_URI[sha256sum] = "61dfed194f9908f8fae684b9fd6e3eb6dc25a7137eed4e18e1168b164e229675"
