# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db51a84e390d2f812d4405627a5acaf5"
SRC_URI[sha256sum] = "97d71441408d52af4b3dfcd6d786afa8071b388c86b0e2987540b3bc941c2fe6"
