# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b327eeb9c16bb4ae453bedb94edb71a"
SRC_URI[sha256sum] = "4fa264709b630fd722f3c0a2890fb272f19eeb0877dd750c86b1c4369d16b68d"
