# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3566e39c56b367b33a77c2b1430566f1"
SRC_URI[sha256sum] = "5b397388706d49d413b745ca17f0776f8db6c81b3b6001d0490b3f1163d50ff3"
