# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3f1242580e4f1b61a847e979fa13c5e"
SRC_URI[sha256sum] = "33de6d30b7a9337b299d083bf5ede792f785c17e4bf3a9c85dcecd7abb0ea4ef"
