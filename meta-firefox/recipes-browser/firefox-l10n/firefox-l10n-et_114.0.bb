# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b4a07fc22c52343e5be56232c4a0d07"
SRC_URI[sha256sum] = "5b88a842efc8b8adccf314734e56ef5570e8823614f03b1023e7f3ba6ae904bf"
