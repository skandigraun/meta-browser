# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fda87007c588ba77151390181b0ce056"
SRC_URI[sha256sum] = "42cc67b06183a866a6ccf1ae6b9e6ebe5c5f027001423fddb5f8eaed1eba3d03"
