# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "900af6b7a63a5355fad6a63f2f4c5a64"
SRC_URI[sha256sum] = "88ce43bef9ee59d7a82f03c7fe47f2e54f4562de543c18ed4c7b832e0d493705"
