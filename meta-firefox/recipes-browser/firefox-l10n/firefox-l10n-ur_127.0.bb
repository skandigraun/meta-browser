# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed1eb6f218d32a2d783fa6e8c46c45f2"
SRC_URI[sha256sum] = "c0bc517a4b20f4a95964dd73ae55d04710873a699de94488c65137b275519776"
