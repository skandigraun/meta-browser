# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37ae137ec0ce19ff9efe6e26659a1a0b"
SRC_URI[sha256sum] = "eea1a3cb4d5456ba7b1cb213c8cca4a2088fd12a00a4c793eee5086ff6d30c80"
