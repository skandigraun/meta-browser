# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16663fcfebe31f3f3a49d71f019f09fe"
SRC_URI[sha256sum] = "22a5646e02dc717e49a76a13f528740f86e84b09670adb57d3ed4bae9694a456"
