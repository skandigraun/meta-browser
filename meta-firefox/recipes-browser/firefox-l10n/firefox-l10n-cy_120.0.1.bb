# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d409b5dcc54a50341f9387438bd5f94"
SRC_URI[sha256sum] = "44a28cedeeb624ecd203514ee2cc9d6e84756b0a59bd5cced5ee0437c46e8dec"
