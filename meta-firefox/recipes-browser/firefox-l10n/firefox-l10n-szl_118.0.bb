# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fbd9ccef66d0ec5572f775f94b4a3027"
SRC_URI[sha256sum] = "409bb6aad7d6d20dba073b81724774aee457111f8c648f3f082118cec8a9dc3c"
