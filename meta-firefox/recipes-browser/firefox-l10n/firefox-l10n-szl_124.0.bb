# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "034cb68b449c634a1159da85a2c336ed"
SRC_URI[sha256sum] = "1c94822bb08e6405a7f3f200bf32b314671c0f20ddaead2c92c8e1b2f20e4f13"
