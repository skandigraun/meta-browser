# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66461f19ecd3efbf1cb15ea08688ab02"
SRC_URI[sha256sum] = "c0c549a80981868a9ec7c07ff3018e576b072a174ed536784af4b7478d1c37b1"
