# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d22ed017852fdf95679c7be9eedfddf7"
SRC_URI[sha256sum] = "b21ed39d0ee004ecea6b6e564ccea8bb899b7ac1447c4c5270df16217c3bf8c4"
