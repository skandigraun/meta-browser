# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aafeb37b090aac77f5e1cb4087dc2cac"
SRC_URI[sha256sum] = "cc1676c55314e06e990506e385f9d58115e55e6fb00acd0c533d437c4002dd9f"
