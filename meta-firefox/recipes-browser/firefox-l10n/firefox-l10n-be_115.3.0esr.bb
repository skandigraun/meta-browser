# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad3086f8b5a492ad8a9f20dc2909eaa5"
SRC_URI[sha256sum] = "dedd40c3cbcb913cd436578e338a2404fe673e426e55c7f245851d8769bd210a"
