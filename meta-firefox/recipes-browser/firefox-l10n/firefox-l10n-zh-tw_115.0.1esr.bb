# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "740d2ea7a50926bce0b5df10a8e46ec6"
SRC_URI[sha256sum] = "39942baa08e9752f9791c52c605e25e2a5d38a6144c1c3ab92e7230d19c8b0e5"
