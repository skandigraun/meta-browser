# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32ebf55c3f3af256c2f1b74724038dde"
SRC_URI[sha256sum] = "83132a2cd9cf1225447bda2354d4e9a475b99da90522ab9dbd2bec0815a06cfe"
