# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf17bb26e70cc42c6a58888b53b86fc5"
SRC_URI[sha256sum] = "5fcff452788591b3ab31ac83895f6a301e5ed0c7e34ee8e42df373b58b61f252"
