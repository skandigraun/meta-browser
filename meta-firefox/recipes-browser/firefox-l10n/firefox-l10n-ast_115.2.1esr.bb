# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a92ac196fb4240fbc7a2747881fcaef"
SRC_URI[sha256sum] = "cc091b6d636647f6d3af31217bafba2e8d0741298ad010321906e6efc2adb949"
