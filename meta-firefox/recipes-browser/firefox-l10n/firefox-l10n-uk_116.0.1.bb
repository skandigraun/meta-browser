# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9862794bbf8e5d56311c9041329c2b31"
SRC_URI[sha256sum] = "63454150351dfbf203781a28f148c8bdcc1a2c34c67633541d6e0621f1926688"
