# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33911d22c8bb6868c696100930885a8"
SRC_URI[sha256sum] = "b73bbcedd181c149acc935200bb99ad82a0f0a14b113bcfb2a1d9c6c7364c434"
