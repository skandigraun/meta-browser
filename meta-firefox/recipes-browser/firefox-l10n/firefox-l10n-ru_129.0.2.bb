# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93d71fc5c24841718ed065127cff093a"
SRC_URI[sha256sum] = "d8d0dd400813ed4f5f76752cd098b54dcb1f34c3b3b8e930cbf32daa387478b7"
