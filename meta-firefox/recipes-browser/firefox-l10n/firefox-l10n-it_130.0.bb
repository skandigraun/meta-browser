# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f65eaf79c2b28e5050d97b2e73d96ac4"
SRC_URI[sha256sum] = "c084d30fe025c77790a25bdbbd34ce3a82b45b22eb08930245699151ecb5a277"
