# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "186ac14569033fe244c382983f1ff747"
SRC_URI[sha256sum] = "9e31b0460139a7918293b15ba4c1f1150f0a7189cb2d8a70a3b2c212fbe7be2c"
