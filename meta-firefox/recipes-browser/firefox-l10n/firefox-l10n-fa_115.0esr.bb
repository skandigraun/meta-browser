# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c293a049072827397316c63a78068d6"
SRC_URI[sha256sum] = "0fb5f09e78cec58430158928a3701f842882c9ae37512b585f61cbe7bd62e5c5"
