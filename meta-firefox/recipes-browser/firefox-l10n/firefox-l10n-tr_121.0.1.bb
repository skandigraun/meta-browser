# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ac57fa931697884bfef0d455e0f2256"
SRC_URI[sha256sum] = "22f3f5c8ed367368d8f0b802fde15fdd23bc88b5c0b21697243a196c7520d4bf"
