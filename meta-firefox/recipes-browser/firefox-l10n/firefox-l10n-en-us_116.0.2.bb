# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72a403a2d8497b2d0c40e3f4b056486c"
SRC_URI[sha256sum] = "ed604e6e92f34ca804631773b32057cbec603cc9637584051437015c3debc1e6"
