# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "312090784498bc93ac1f268739699772"
SRC_URI[sha256sum] = "4a79941ed49abea38b72ca96fcee2e4334d31488e4f2010f5b90f73196a6761c"
