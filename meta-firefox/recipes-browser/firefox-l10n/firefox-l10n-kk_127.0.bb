# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcabce6e666740c3957dc54876554d3b"
SRC_URI[sha256sum] = "79c3547a30ab26994560fb21f83df6f40f312aaa2205c7fd551678dbbfc285b6"
