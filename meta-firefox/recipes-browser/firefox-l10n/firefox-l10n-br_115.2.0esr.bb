# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77599f2d9d3506530cc1e125e1c4a2e4"
SRC_URI[sha256sum] = "1496d2617f6f6af78861e834d27b4edfa2a2ed270323d72fd708cb44055fa8e0"
