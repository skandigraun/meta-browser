# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "933fc859ba08a5cafcdd2178d54c8b38"
SRC_URI[sha256sum] = "ed24fa41ab0cf62e477bdffa6c11455f624fce22ac384382ecdc2e33bbfbb6ff"
