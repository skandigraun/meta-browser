# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "405f789596edf5237134698973f67d7e"
SRC_URI[sha256sum] = "b1448ce20f5304c891d68a22f467e037d8fc179d5f5082fffeb5403a0dc6853d"
