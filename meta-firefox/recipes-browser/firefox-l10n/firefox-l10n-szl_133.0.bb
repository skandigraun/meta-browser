# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbe0c096f57c7cc8005c07560b45f181"
SRC_URI[sha256sum] = "fe19b172a00b8da9b3ecb05a5e0bb7105ba8577e7a1cc0ca1153b9e2abdef4aa"
