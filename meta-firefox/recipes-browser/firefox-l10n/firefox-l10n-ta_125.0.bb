# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cb533d85130451e2799d741963ed2f2"
SRC_URI[sha256sum] = "c5386cd4052eac6d8abdbf021f5f3a26420f53b776edc5aee9d40066e334ca28"
