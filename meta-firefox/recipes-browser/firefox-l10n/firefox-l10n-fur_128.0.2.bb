# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53db1eea57f31b45be6ecc652fe51f55"
SRC_URI[sha256sum] = "93a40ed166eaa9abded4dfc46ffe49c49a05e760e99573fd6e4b0670fc31ad34"
