# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45172a12e6460a4d36092205c1aa7bfa"
SRC_URI[sha256sum] = "837fd4a032a24085981030d81d3c3ef9276753c67605531e91788fea7429847a"
