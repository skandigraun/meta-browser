# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a8fc50fafe1480a29f4bd29d71409af"
SRC_URI[sha256sum] = "9b0ddacfc7b3dca529567544c2a73251f40c50a6e077b9d8f54df242f4e6e3fc"
