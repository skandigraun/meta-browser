# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6f92b3c1813a466e35bf91820cf0ccd"
SRC_URI[sha256sum] = "e37ca54dbd3506ca177e812305c5ba870584131a16958b8c46c7f2159172982d"
