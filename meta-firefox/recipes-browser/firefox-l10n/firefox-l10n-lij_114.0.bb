# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d79579f19783587a7627d7320f971c8"
SRC_URI[sha256sum] = "0a8c4f3c3f541cf4be8ac72c5d8e9cc85852568ece273f4173c71eb637d406e7"
