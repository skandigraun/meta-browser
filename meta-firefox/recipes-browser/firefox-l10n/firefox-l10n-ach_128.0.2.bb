# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "311da247b7937e14e2a38fd83e8aa118"
SRC_URI[sha256sum] = "7829b54cb8a55d013925e03896f33bc1337dfb54a3f19582bffb8d981cbec746"
