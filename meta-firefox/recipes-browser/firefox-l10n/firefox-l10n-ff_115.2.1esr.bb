# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64854c79e5914153a4d37b287d708a08"
SRC_URI[sha256sum] = "dcdc6dfe92e92c75e88a710a0870fa6c2ff9665940f3f9e02372edcf1c55a305"
