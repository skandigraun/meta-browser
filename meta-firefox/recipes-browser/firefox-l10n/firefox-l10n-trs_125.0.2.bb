# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e36b9051b82f4e1008ce755ef771e492"
SRC_URI[sha256sum] = "ffc9e2bf45cc421e94e4aa4f7a433075fd62fb27d7f2df21198597802c90c09d"
