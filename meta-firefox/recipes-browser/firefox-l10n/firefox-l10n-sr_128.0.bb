# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "211096928030716bb39383ff4c7a1ea9"
SRC_URI[sha256sum] = "ffca3ca95f45b950ef9818491e5d07b5e24ba2af92823bab5dee96b74bf3a1b5"
