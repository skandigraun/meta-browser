# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10b4ded57f82f9f6e59789702b74ee8b"
SRC_URI[sha256sum] = "d59e6433db5fdb41ce989eacf17daf301e83b541c2e94bf0b126775bb7ff50dd"
