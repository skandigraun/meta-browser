# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74dc59834035ab8ee05f09e3a4184e6b"
SRC_URI[sha256sum] = "34f77872174d8bd7aec14a09be1263599d2240641770adab7369112332bd926b"
