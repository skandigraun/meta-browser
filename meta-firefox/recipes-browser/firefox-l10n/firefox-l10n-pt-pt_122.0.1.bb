# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b498d65c82fbf5b0d3cb93a2424ea00"
SRC_URI[sha256sum] = "74d32b57c269243682b636bbadb171af547beda211929eb1c04797cd8eef5af4"
