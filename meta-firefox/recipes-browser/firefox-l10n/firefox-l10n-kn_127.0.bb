# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1256dcb7453bed4aed3089b1a7e9f28a"
SRC_URI[sha256sum] = "d3cb2116a7638d6938eba8257ebff366b2c0fd5d5d5b80d690af1ab9f95ea183"
