# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c10bbc9818dec63d4db4988497d1023"
SRC_URI[sha256sum] = "cea3c8d14c01ed6303a2489553cf8e63edc2956f3c963117de07c5aca23f0014"
