# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b24e031d767a6b982626bafa50e25ff3"
SRC_URI[sha256sum] = "6be914a539ebfea7a4c0c85afdd88383b3a281f2cbdd25d5e5aa9b9d391937e4"
