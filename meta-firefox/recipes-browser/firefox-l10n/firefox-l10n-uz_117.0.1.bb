# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "694c640caf21da23cc45afaa689351df"
SRC_URI[sha256sum] = "12c521fa0432894d43ca61f8da71d7041c61705edc3e68dcb17f416f93e9bc97"
