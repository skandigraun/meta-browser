# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b0db9a56288368588682d71e61036ce"
SRC_URI[sha256sum] = "b564fd059e81dd3b4649676393006eff7276aaf72d15e8477584a4643bf2bb9c"
