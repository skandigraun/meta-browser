# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22422973ffac1293105b38e93d167d6f"
SRC_URI[sha256sum] = "699c65e3784aef83a8d0ab6ad652bdafb02d99674fd8381da352f6175871759c"
