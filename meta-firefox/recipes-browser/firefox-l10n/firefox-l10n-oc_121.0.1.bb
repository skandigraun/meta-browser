# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f23feeff4f5b5c574a74b6440b41c8fa"
SRC_URI[sha256sum] = "800d092e7f4106afc9aa04fcf320086825d3ffff459facc0d0bb8127e5e26929"
