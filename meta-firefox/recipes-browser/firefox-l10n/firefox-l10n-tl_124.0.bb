# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "188d9af03672d3c9a3b1e3cbdc48576d"
SRC_URI[sha256sum] = "3c6bf3249c0973d436f4b57f5ca92ed3b1fc7364e8a364389b56625a3c4c6ca7"
