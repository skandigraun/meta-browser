# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82e7f6ee95dda6db80d9e8ebc99bf6b6"
SRC_URI[sha256sum] = "f4be541649276fd7988f0c626d5b56dbc6e8778f1da0ef0c13d06ceb414dfbda"
