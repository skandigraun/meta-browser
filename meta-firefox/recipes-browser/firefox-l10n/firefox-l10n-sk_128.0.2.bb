# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "016a92fdfee09b9987ee00025706bd7b"
SRC_URI[sha256sum] = "4a3dfe42f51f120ce163ab022e8a8085ee83167624c9513880c59e3e09e10b2f"
