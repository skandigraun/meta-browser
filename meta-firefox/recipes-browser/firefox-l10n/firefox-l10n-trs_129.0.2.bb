# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "618ca9b925fd5d307735f26300787b66"
SRC_URI[sha256sum] = "e2502abcc8c7637d85b23db0e6fa7e6a1bd54b5311ed8d7b89d4cf4bb9e1ec4e"
