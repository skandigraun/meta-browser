# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f553049c96e7d211c546edea581da4fb"
SRC_URI[sha256sum] = "c7a8a6f481eb13163a403085a6154e54379bdfc80783b4e68f7e940b22832135"
