# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a9875bad23d726ee42ae06aa40ed1f"
SRC_URI[sha256sum] = "16880d5896d6df52c0b0e6bfac3bfffc7978d6b96be5f92dcc6136357b651249"
