# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "191fa9a70235867dd9d64ad0b53235c1"
SRC_URI[sha256sum] = "7f67e73ef1bf384617481c7c4e98f2982f65f810ef9a03e5c5d07880c888841e"
