# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aaaba1c4427f8346ee300243c54d89d9"
SRC_URI[sha256sum] = "a6d4a7f215a9058355996512434866d655c22719ce51428b6dbd0d6886745a7c"
