# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6a9da9ba9a3432e920aa03409145f76"
SRC_URI[sha256sum] = "3d43990d48a96f0badd1973ace95a5a17063d2f2bd30515f75d451cf7d76356d"
