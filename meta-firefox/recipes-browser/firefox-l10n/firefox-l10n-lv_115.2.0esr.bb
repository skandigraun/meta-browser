# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbca450404a9d222e9fe2db7ae5389ae"
SRC_URI[sha256sum] = "b37daa0f5f3eba8de0205d07d07a15a408a252f8ca68e37e8a2c7bf23dce9f91"
