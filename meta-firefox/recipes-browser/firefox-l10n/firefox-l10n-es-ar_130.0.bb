# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db2200bb34c05d19cbcbf0313c2e36e"
SRC_URI[sha256sum] = "2541ad15ecaacce5c257d528375f61d5abe34bd1f1387095a35e8a6f3cbaf05f"
