# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56c2aa1b75f146b011d1e1373543a455"
SRC_URI[sha256sum] = "ccb538ef14becc9d6ba8e63e852a399a19b2446cbbaa30aa2eacca74c53a6bf6"
