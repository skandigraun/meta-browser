# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77b5044e7b2927a30a508fdfaab795d0"
SRC_URI[sha256sum] = "c5938c0851f8073ed8afaa252e7f97bd1151d347526a8ff27facde34fe1e99a2"
