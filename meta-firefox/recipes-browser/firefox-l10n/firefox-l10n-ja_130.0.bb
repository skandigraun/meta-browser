# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "442bfe82cde615e5b6e26815d53a4cc3"
SRC_URI[sha256sum] = "694bc5e0d5ffc9f455b1e5f5fee7c3c82c1bf99ac407585efcaa8313de9e89ed"
