# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ace05b9bd237b4349ef53253233c3f7d"
SRC_URI[sha256sum] = "eae72163ae3f2be0e3d1d4b207cbad6a8a64c91228018a1502140331ef8d2c4e"
