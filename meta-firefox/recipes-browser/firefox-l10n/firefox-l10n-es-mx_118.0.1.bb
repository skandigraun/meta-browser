# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f8823a8b7ad83705585f2ae73d4f818"
SRC_URI[sha256sum] = "b8c5c268e549495ec2886974ddc9235d52f2c567c4776bbcf8c2be51acaaa282"
