# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0b7cbef8762771829f897d90fdbb548"
SRC_URI[sha256sum] = "cbc14e4821cfca66145d5709f3b5b80dfeb7f631bdba02241492f45ab2c4b70e"
