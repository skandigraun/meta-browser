# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "734fe12da11ecc9ab6b28070cda2c1b7"
SRC_URI[sha256sum] = "3a96275c9998a20a805950f48b49645ea2ede103fd2dd7383bd2ca893aa9f8ab"
