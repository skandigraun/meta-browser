# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea063034cc924fc8b34cfc5c1591c94"
SRC_URI[sha256sum] = "3721915d3cd0812f83627bd13cdcee51814fccd4d3c62ac68ae1fc9aea56eccd"
