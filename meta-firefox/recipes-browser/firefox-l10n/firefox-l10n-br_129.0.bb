# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa71883b3f9243d89585b6729da3c8b4"
SRC_URI[sha256sum] = "d41947fa034acc3fff4888c46e36266f0ffaae628680893798a40f45557b54a4"
