# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85ded74d5eac880540f12bf383b74316"
SRC_URI[sha256sum] = "02e5aa0e881d9f8c62272b6cf1ea541f32887e2d3ed638b11bcd88108a938dc3"
