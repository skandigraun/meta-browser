# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5952674fa9b9b5045aa1175fd6d2c6dc"
SRC_URI[sha256sum] = "4e3ebc7bf7ba326a4e0cbf5a65211d76755374ab46b382ba5bbc1b94fd8e216a"
