# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afed3076ea6c51cd544e9b28ea1f55f2"
SRC_URI[sha256sum] = "74c4caa5403b4c43730c38c9f1d273204f10250ad7a6b249e5530efa60811b06"
