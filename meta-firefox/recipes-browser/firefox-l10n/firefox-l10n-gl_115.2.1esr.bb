# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f95dcff08552de930335f209232631f"
SRC_URI[sha256sum] = "ff5592f07d05ad7f54e8b6dec5fbaaca8c96794f4b141ce721216cefbc8feeee"
