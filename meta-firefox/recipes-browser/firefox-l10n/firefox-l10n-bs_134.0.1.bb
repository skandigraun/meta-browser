# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0abc00760acc492db9ed1cd5bc386e65"
SRC_URI[sha256sum] = "1c30ee2455a78832624c6ec3d135c69f1b9d071017d9742bf40b0f0f2a911933"
