# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85156c94d1a84b7e791deb7e3a3fd562"
SRC_URI[sha256sum] = "13fe6131d204a67d912fed6673f2009459e0e6a6cb62e01e119abd4adfb4917e"
