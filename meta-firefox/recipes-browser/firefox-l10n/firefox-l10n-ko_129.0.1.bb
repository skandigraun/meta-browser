# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "421830060f2ac68ef9abc542fb68d993"
SRC_URI[sha256sum] = "42f2b85c331ac61f43c8f221a7214c5f21710d4bcd9e5066c7b28ddd895d069a"
