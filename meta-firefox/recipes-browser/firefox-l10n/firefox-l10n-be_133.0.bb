# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5dec90147694af420853c21738e43c69"
SRC_URI[sha256sum] = "d91688535d66dfde3a671bb1878e854a399bc869b56dece9f01a5144c1f0093d"
