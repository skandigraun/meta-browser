# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5e4c45bcd840c225755b5268aa8b54c"
SRC_URI[sha256sum] = "bb48fca7038ddf31c48eed66de5a41880ae6460bf35df88a4bd6799eac2d645e"
