# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cd572b0d794bc8356f48f81e4937cec"
SRC_URI[sha256sum] = "baabff3f30f8e1d52d6fb592dd3e9147238d7529f6db4279af7e0c95656e543f"
