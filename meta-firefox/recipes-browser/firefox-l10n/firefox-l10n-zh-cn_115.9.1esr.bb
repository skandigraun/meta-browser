# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02fe730585948a1e09007cb108bfe5a2"
SRC_URI[sha256sum] = "d442ee6ddd9a2704fb09cebf6568494a1a86e824ac02b7f448be87a092b926ed"
