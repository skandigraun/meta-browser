# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "766cdc967bc833ea5a0ce68d77b5866a"
SRC_URI[sha256sum] = "994226ac6c5471f4389b44900568cfd9fec7ad6bfa0595ba11d37e4ccf641731"
