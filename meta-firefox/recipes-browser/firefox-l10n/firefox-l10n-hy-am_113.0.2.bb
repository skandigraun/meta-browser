# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c76d47833575d2f8785296b85a65ce2"
SRC_URI[sha256sum] = "b3fc0491528dc1126090b80e6d0d5908987cabad9ae9ead34304c06ab8c67b34"
