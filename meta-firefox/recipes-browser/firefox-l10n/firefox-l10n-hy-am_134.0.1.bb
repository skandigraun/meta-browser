# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcb58bcdc45c308faa3efc8c0ff11a4f"
SRC_URI[sha256sum] = "8682f5cfff20535cfef1a528d112136228c3ce5f4c6b095126008d9eec280cdf"
