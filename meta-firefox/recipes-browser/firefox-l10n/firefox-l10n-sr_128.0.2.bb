# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1969fc132dc3668edfaf09a8bd34559"
SRC_URI[sha256sum] = "62f22342ac84b438067b590d07eea3f36a067aec1b86c542bace0fbf0c6d191b"
