# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23f2f56027ed5188206f1fc50dc925a8"
SRC_URI[sha256sum] = "e832ec9a2d4978aac9bbbf9cd7222b24d5272a3ccaa52224eab84478eb4aa29f"
