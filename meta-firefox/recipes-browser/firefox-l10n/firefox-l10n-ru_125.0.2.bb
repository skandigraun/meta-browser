# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84fb17528c1f716b251e941e45f0e146"
SRC_URI[sha256sum] = "0ab6ecff696abfa549bce937fe053ce321a1cd3cce7dfa05f5f1e59420b650c1"
