# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a49dcb36fe6c7c05d3cc3771ae9e484"
SRC_URI[sha256sum] = "8d9b8d71fc13c261aa7b2370094ce9d8348087e1f1196f2946eb7a45e2be91cf"
