# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0497b267d823015d1a9cb9d8c71e14a2"
SRC_URI[sha256sum] = "e2fb9a5081e9629804ff9ff31db5515a2d89f32e0d51779e21bf1a01c4f06e6d"
