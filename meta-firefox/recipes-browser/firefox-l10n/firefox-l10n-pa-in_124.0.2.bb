# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49a8008c676e6e554810e3f77db676d0"
SRC_URI[sha256sum] = "d8bba43e70975a0205bf49b4ea7d1b4d6722353cd96f6f940f813caed6516564"
