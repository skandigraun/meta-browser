# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e522f896af5d790bce6dd82afd1d0160"
SRC_URI[sha256sum] = "c9b7efb1df9810ee5da0595240ba8e75ca704d137154c00148181095552bd1b7"
