# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "308b07c8651a5901b0a32e572661f0cb"
SRC_URI[sha256sum] = "fef34f33cf453a774bca393db29d9cff6fee38ff38bff9c0b4c61eab65ecee8c"
