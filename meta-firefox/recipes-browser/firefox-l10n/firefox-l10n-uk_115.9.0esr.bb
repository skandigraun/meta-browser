# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dae5dc3d399c27f5489592ece22aa042"
SRC_URI[sha256sum] = "5a752b424d1f7c1c73556a08d928f6807a89908af08425be79da3ff61d77a78c"
