# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6584f463eb80d57dcff1fc3544b27f7a"
SRC_URI[sha256sum] = "aa11c8ca848c72b0c324614ba4ad36b6fc081e46588acc50666d569906a63e43"
