# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ed103e80051e4d716be8e5d0154e137"
SRC_URI[sha256sum] = "2004bf063e719b968373d1f5054a88edc99a3941abea47ad58d728703cf21239"
