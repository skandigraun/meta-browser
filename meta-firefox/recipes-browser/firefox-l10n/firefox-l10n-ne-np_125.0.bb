# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5eb82d80d30ba1e46f8b9505802b65f8"
SRC_URI[sha256sum] = "e09df3db5c2a2a9431dcf13c296ffb04e77c46d22cb47c98652a7c0b7362e6c9"
