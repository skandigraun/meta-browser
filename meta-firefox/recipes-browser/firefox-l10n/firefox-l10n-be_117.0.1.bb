# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3baa6dbb9bdf4afa134647fb53fe588f"
SRC_URI[sha256sum] = "53a4eccd11eb6bff7b727b5b58858aa279c6cc0e568635ab7721e4486be5a0b7"
