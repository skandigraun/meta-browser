# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e56118b61329c55feb7e64d220ae3afa"
SRC_URI[sha256sum] = "8b3c994e1e721969098c0f87d8438477d8653ebb076f22866662f5b587a031cc"
