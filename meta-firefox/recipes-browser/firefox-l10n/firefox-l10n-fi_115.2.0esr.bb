# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d81d9ee7356688e3be7bd5ca5354e039"
SRC_URI[sha256sum] = "adbc40b18230dc9ce41cace18f35f71a2ddd227553be08fd65a680f563214da6"
