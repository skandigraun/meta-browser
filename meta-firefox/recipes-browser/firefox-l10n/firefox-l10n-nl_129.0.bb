# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1907c4d924190a62687861de733146ad"
SRC_URI[sha256sum] = "39209842109a14a0bd32b477c3fd0f40e57701b5d7b40f6ef40643621e9d49f1"
