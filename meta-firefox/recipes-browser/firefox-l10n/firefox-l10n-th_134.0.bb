# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ec0652ae015cdf8cced916d480e81a7"
SRC_URI[sha256sum] = "40e30b35dcba81894031f7970bdf503572d114d097f4d0de6a236f7eb33c2dc5"
