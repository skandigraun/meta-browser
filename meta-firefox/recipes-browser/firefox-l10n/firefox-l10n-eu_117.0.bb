# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a9706ca017f3a9d6b129e19b88dcee0"
SRC_URI[sha256sum] = "610d33867b9e9878e44aa7359fba78cb9c90687294ec23fdd2b2dfd8f92c19a5"
