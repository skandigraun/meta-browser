# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f2bfa97d7f750e7fb9a7053ebb447fa"
SRC_URI[sha256sum] = "2d9e5f988223d0e815004c6d73236db738b31b0b9c3da11a3623b74756ac7c2e"
