# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19822cd9c09cd5c7a2a7f4559e8c2452"
SRC_URI[sha256sum] = "0ed97bd41625d98304a0ab0149919ef5461f449f5a8a118fc12e319213a950f5"
