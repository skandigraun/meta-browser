# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9b981af07c9de43540a5605199310828"
SRC_URI[sha256sum] = "0e3feec2c38454cf96e50df91f060b14f07c1a1e007a2d2f19a435b237d7f841"
