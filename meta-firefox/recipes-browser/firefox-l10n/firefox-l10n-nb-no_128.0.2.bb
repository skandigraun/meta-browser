# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9c4b55aae771f90b7d94f42d647ba5e"
SRC_URI[sha256sum] = "2f7eea5eb139c5ec8acdbef129e14a2f2c0b2538dd3c934ab9e498ee384ef4f0"
