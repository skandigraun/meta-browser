# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43a5c6556a3b88deb21ca781055325cd"
SRC_URI[sha256sum] = "174026a85f3b5f8f2f3e8815919e5ea9f4bb17cb87ea9bcd75ac11447c4a1085"
