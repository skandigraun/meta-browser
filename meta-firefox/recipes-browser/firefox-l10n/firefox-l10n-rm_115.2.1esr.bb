# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e54dfa65851bc014a731e35d9fa8d15c"
SRC_URI[sha256sum] = "95e38543ca5312185830bd486d79036ee85046e60b5769c59d6a2bcfbaac4d2a"
