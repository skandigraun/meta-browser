# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6207011e4a0f5949ada26cad936dc24b"
SRC_URI[sha256sum] = "4cd380d96be058470a57bffa2da368d6a5c9cfd976fd2ddd05c052beb5c3b1b8"
