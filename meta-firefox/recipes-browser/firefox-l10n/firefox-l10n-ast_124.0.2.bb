# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab2409d300fd3b302d019de685706df9"
SRC_URI[sha256sum] = "092cee8bce7efd251cc47b772af6969a94263c6c198859aab96fedb2301b133f"
