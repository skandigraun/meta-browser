# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "732dacd8bab4b559a7c5bf4d1f2ce001"
SRC_URI[sha256sum] = "238359c9de2894eae7477d7087579d8ab81bb3dc0dfb593bea673a0fd24d4850"
