# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1844797019e19902cda5a9cac6fbfe2"
SRC_URI[sha256sum] = "8c9db2fd401d258172649717ae2d6de250c7710a8bfe3c918146b8dcce94e7c4"
