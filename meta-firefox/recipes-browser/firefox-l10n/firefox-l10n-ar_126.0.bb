# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3b62ce5aaa02db0d6b2eb185c9ecbd4"
SRC_URI[sha256sum] = "61afa4873e0e6332dd2086b04147dbb28f3794f1f4b08a9d519f4f2def4cd169"
