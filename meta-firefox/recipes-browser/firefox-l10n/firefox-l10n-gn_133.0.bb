# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a35ccfbc1407a164d735990614364106"
SRC_URI[sha256sum] = "0655c39d56b52f395b41511d30e06596fb9c29f47cdd9126b8b177d60a8b1f79"
