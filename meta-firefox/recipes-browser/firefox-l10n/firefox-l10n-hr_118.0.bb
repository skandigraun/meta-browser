# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b551ba4bff5dd0c8a526e7eeb9546da2"
SRC_URI[sha256sum] = "bd58602a915a72194f2fdf2debc08099a031b08e3dd20ce355a3019f2b058aa7"
