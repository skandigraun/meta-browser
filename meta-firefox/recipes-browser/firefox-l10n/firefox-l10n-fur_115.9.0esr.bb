# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b691e6ce8d55783fd8997f7dd3f5c9cf"
SRC_URI[sha256sum] = "59bdd916afd16f3831d2b107a6c84901189775311930080d1e935ab3fc3bb3c0"
