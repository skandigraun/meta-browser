# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd6e7508be684180d1c42343d9e5b342"
SRC_URI[sha256sum] = "971c38b67fc0af306d4d3c415c283661bb71beee6962bf69b8686572eac6398e"
