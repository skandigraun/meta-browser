# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7efb19421c1adbbe52048e0c8ebec72"
SRC_URI[sha256sum] = "c56039b28ede8a32ada1215468ce9fdf3a36f18c78fdf2e591c37e2ff670d9e6"
