# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13760b7f916d38a0f62eaac654190ff8"
SRC_URI[sha256sum] = "96fb255298c37df8da31e09580da6f6d0d2fbfbbbb6fd8dd7e3967bb7a2e6e5a"
