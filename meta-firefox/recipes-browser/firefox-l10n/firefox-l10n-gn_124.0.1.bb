# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fdab18c41b8fbe7c0eee6925909f133"
SRC_URI[sha256sum] = "76f1628846f7ad27d9a9e82267c6976ca211a917be25e5636c34b4e9fadb11fa"
