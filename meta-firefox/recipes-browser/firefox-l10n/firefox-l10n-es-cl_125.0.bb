# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7633adf9cc3415c7f95fb5000ed6a38f"
SRC_URI[sha256sum] = "c85aff363fd93f6fdee692a0cda55caa91cee16796ed129669c67028cc77b31c"
