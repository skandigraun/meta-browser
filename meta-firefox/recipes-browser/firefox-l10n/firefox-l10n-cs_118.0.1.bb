# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a98e76598af575e1fa26a7dfb3947b8"
SRC_URI[sha256sum] = "c8febff9258639dc5bfa74aa1f9adfbd0c4cb169f60e3fa909cb46c9cfdf54aa"
