# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f58e62ecc3fe3d92a093e26a4fda8a2"
SRC_URI[sha256sum] = "ff0d87f840cb82238c078ba02aa1b56d9ef453926abf1a6711da1401a7cb6ec7"
