# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e51b1518673a771c768b7038ecdffc9d"
SRC_URI[sha256sum] = "da9c1080ba5df2d09c6cbd185157bf388b9df0e795208ef3a4d6135b2f5015f9"
