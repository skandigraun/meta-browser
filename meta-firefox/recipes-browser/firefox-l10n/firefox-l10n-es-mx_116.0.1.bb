# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37ea548e8c5237395949cb5ac70bf0a1"
SRC_URI[sha256sum] = "115a78c779138673345434a17343f0776231b04777d77ffe9dd0a7f1e24cc437"
