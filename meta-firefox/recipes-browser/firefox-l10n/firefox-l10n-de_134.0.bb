# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ab5abeb538e576f876e1b46ed92fbe3"
SRC_URI[sha256sum] = "8a8f7a95713db855d09fe3ec09a8f80b477f572c3412cd78ac5539c07841384a"
