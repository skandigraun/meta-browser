# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a25eae46ea606ea3085466ee1a718f48"
SRC_URI[sha256sum] = "92a0dbd7b6e07dfa2e120070f73db0dbb2f301bc904f4191535de27f59e98d48"
