# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ef539d4e1fabb9e8953a1aa7f9c22aa"
SRC_URI[sha256sum] = "e30e1b1fff4d548d3f6873b1b6bf92e138c758ad47690a039771ebbbc66ad34c"
