# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9611e98b958288a16a51613c6321749b"
SRC_URI[sha256sum] = "188111b635e7f54fdaf356c057baa2eea0a3459c1d68dc4685c7d27c1f3d3849"
