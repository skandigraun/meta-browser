# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4db2a606bed1ff73f5ab4b68d51d697f"
SRC_URI[sha256sum] = "700b33fa27fa90b10fa8c8ecbd5feebaab960dbbc3a02a2ee230f1ce96cb7009"
