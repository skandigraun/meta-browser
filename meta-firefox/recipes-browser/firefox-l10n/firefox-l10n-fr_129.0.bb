# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38ed586d33c09b677d14442257b12f7a"
SRC_URI[sha256sum] = "1d412016c6a956934e97ef89af7de48e9349cc5513efac3ba5186d19cec491c7"
