# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c53f99cbc76f884173ccff0e9b5a1140"
SRC_URI[sha256sum] = "de448006cb71e596980d152860fb37b69298f56407de71c58425e92c5606ca83"
