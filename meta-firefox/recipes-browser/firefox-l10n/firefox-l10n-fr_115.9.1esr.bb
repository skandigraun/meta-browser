# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82221b9b62c8648f145dec2622b38b79"
SRC_URI[sha256sum] = "10b93392ae7cceed4dc55449770b220681a7aecfa272edeec934a1d3ef8ab844"
