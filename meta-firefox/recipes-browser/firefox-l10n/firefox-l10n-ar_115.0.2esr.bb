# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01221717287af44583b32119f3d5cd02"
SRC_URI[sha256sum] = "d2e890fdd93eaaecda4e7868c8894a06191cb556d513f5581d9e9bd33ac77351"
