# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae38213490939f912eaff0e5a5702745"
SRC_URI[sha256sum] = "fbdfee2acf0a04402203e6f99d3a03473a704cb53efce5a8790b61cf799428f3"
