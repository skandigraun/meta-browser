# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7247c4f9b765801222afda7b96834ce"
SRC_URI[sha256sum] = "2c30c76913acda89876261bf0a9e2259aecee9f9168641c0f5ab14b962a636d6"
