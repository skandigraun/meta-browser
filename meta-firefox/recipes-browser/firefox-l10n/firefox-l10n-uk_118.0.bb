# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47a10753d67e58d0987a63396f6d79ee"
SRC_URI[sha256sum] = "da9c1b62582a0b16677e97026a41c1b3dfbea6591d810b23f105aaa41022aff4"
