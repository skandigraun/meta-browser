# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f2293fb821491ce7febcf358cc50468"
SRC_URI[sha256sum] = "8a9493f94682791b6cb169f0eb374af6613556c9dcf7bfd4bdd5029d01be9bc7"
