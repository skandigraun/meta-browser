# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8aa80a1a06faaa5a97cb68dd853586eb"
SRC_URI[sha256sum] = "e56dcb0f97a9c59072a42bb3a1b6ec90132b58a1c7a23c1edc1d2595219fe8f2"
