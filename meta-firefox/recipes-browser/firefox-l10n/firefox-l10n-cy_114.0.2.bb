# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05a876671b8db71c0e65f4c13f4b8679"
SRC_URI[sha256sum] = "363eec16e8062039739c809ee133f3a488c5d60c43f9edb5f628437c3aa1f8b8"
