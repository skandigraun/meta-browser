# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c9bfc20feb1d2725e72c20d4a972b75"
SRC_URI[sha256sum] = "7005d61653aa0a740fce3c266e317641276d1864fe91cc7823a1e32f1fdbc237"
