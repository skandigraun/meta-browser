# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76b9ee992d69673a7df7bd016bc7c0df"
SRC_URI[sha256sum] = "f1b72716e04c9620f7b9b87b4b1cbcd3c8fe36171be391905495e6cb3a19d193"
