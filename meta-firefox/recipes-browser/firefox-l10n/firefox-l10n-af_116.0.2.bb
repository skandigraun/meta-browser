# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "496f9b40d829ded1ee5a8e50cff9aa10"
SRC_URI[sha256sum] = "f88d186f0ce837c53580f274ad1f6d4812d8417e758ccfb109eb1581157537ab"
