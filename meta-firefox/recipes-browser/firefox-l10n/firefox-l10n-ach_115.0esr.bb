# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05636efe6ad372ee0ad21e4f4fc4ff0a"
SRC_URI[sha256sum] = "7a77d5d915d69c3c8d421c8fc00d72e04c98b3c9459c9639981857e244cbdf45"
