# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a69342476033ecdec9c174ae3082b61"
SRC_URI[sha256sum] = "868a89b5cac7d5775944e42bbc120902edb92e7fbee3132e90ed73429843c3b0"
