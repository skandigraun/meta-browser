# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02373b6cdda96208b5f9b3e18bdc1897"
SRC_URI[sha256sum] = "996dd18e000c9755e812fd715acebbb700fe583ca223fb31d30c5521fdce3a54"
