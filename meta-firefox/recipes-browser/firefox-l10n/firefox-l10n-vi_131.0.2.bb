# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88e6bdbde0fbb02d5de0b481d2c66c47"
SRC_URI[sha256sum] = "7da599b56842b3c7729ac0cf8687890947a5f3923a0143536dcfa211851becf2"
