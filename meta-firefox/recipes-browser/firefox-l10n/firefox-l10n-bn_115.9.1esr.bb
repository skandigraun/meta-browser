# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e97614061c72dd5c918da91b20ecd921"
SRC_URI[sha256sum] = "863ec5f7a615b0356ec7b99cb02210f19c8dedafdf8300a123024f7d1935fc1e"
