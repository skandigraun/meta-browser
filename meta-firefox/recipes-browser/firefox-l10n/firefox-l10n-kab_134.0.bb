# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcd16c5bb26442cc7ec9774511a9cf6b"
SRC_URI[sha256sum] = "c441d4abf06e1a768dd328c7c84bd09fb165a53b161bcbd02687b638c0edb3b9"
