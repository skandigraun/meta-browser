# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8772e321aa2ea3e2e2c57d10a96473e8"
SRC_URI[sha256sum] = "ae0ca4a8bdc028e1a632a90acf43c0721189aebb8bcfbf41590ed9eaba0b65ed"
