# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71c594a4bd18d744864447d043a10e23"
SRC_URI[sha256sum] = "d98f7b1e40adecae29caf8719b806f86b52309db9ceb569e4144ac77667f8124"
