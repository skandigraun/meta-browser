# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53ab81a52d1b3e069799a709cc1294df"
SRC_URI[sha256sum] = "0185575560595cd58b8526ba5450c395b0c513e360b523e57be37c3d0af05744"
