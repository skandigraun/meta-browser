# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "893417f917cc6beb15acc03da7aed913"
SRC_URI[sha256sum] = "8a27b1e7697e86d9e923b54027039b8bc7fe4445b6cea7883cd3a3d27ffb70f0"
