# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15e87982106b7565caeeaa01d4a71bb7"
SRC_URI[sha256sum] = "2204b2cc96aa775d6111029b21a6d83ff9c0c168237ae1703f645d4fc9084061"
