# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fcd44c833003fd97656753a84df9956"
SRC_URI[sha256sum] = "e485909afa4718319bb03b8c958f296535345a0ecb96b14c45a54badc8346382"
