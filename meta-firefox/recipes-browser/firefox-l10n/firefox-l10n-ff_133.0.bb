# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee582e9e859e44cd67c71d75722fac32"
SRC_URI[sha256sum] = "5d33c1d527339438dfab52718094c1e918d242a9bc14bb21d963ee72f45673c0"
