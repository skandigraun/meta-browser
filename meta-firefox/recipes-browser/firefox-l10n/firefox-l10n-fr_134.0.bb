# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3e45adcbfe706b74ab98be08379012b"
SRC_URI[sha256sum] = "6ac218cf3e74259293c3f0920449a343444a2127541472666285eb5b6057286b"
