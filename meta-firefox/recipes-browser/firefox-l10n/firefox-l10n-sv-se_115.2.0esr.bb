# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39376cb6ba30201fa45daf42f0153925"
SRC_URI[sha256sum] = "3453e02ed3acf6d7b55df7bc1e177c287d03caac4b97f594ea8defe8d6b563b3"
