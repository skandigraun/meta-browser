# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ea9ad9566731c96bc63cd9a6f2a3768"
SRC_URI[sha256sum] = "d220737d4749948d97ffeedfc3b53e4ea837bc59e97f4a26fe8bb7e16df96789"
