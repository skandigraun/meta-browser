# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8a7a62b2440519092e9daa6c4575a6c"
SRC_URI[sha256sum] = "1156ce0e76f9a18bcf103891d47e008e6972b6009bcee4497ad9bff9e928c322"
