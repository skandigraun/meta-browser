# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81b2f2d96b15a8d6c924908fed60f313"
SRC_URI[sha256sum] = "d5a530ed980cf2deef0c2c2b453825d482b9238cfd0283f2143163e47e627f5c"
