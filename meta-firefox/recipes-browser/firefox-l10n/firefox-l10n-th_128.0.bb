# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18876f9582f2bc94b5c3ea2e349dd5ec"
SRC_URI[sha256sum] = "0bf6120f49d392ad393ccadb715619e485963f703fe5013b0394a1efe483cc75"
