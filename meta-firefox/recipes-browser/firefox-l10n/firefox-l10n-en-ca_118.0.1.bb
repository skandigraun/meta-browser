# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "670cbe0cbe72a1ffaadad281ef9abab6"
SRC_URI[sha256sum] = "27b507869b626b1f05cdeafb2268586172ad8f07401f9f145775c47389f51d8d"
