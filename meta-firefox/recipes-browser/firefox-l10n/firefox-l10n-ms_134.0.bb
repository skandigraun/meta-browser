# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5caf7a5345b4e4273a6e64fdfbc709e"
SRC_URI[sha256sum] = "f1f59841dd6820c3d017a93c0e1fff98903528466ca20975ed15f9778b5a86dd"
