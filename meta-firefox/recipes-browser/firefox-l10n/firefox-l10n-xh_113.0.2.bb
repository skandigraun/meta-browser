# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c8b22e6b200394a75d8192583d4b68a"
SRC_URI[sha256sum] = "3096f48bae5b4fbb9007e9c088336cb66258ae4e09ead928a7e1f072933c399b"
