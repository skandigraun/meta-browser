# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60db89d579d5fa87e79dbd887a1ce7b5"
SRC_URI[sha256sum] = "3daa59cf481e239ea4ec9a20ced5ab2b814761645dbc726f3e705902bcba1f8c"
