# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3de3d58d287f8d630c3d4e2a2284c5f7"
SRC_URI[sha256sum] = "eb2cd6cdf4cfb0eb59c6236bf2bb86c425ad6f70c89d311d2e6488d7b686cc9b"
