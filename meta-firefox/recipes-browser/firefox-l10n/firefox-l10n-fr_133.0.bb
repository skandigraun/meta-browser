# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "608f133a666547b520e97c9a0002ca09"
SRC_URI[sha256sum] = "e29223f3244b9def4bb81a11bd312658e5fe57683b20f0f5eea303efa3e06623"
