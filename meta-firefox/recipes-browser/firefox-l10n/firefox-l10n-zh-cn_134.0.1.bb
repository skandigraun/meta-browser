# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68d29d17b8004c0c0cd0c52e76f7c3e9"
SRC_URI[sha256sum] = "112dad9e511c08d4128af3ec382a8e46b15e8c553a5ce572a3282c245806a127"
