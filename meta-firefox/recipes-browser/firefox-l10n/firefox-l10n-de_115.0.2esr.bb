# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c5d9e20ad372b5bd61b753d24c34587"
SRC_URI[sha256sum] = "34d8fcc272175257785dde6e292185e7a6f1348b1a2caaff91da94132f1311dc"
