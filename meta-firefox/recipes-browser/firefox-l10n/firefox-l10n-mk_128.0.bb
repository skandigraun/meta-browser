# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88958338f6652ca2de2d0130133c65cf"
SRC_URI[sha256sum] = "7fde3ab1389136a2d89a5e8e54506ea3cb3584aaa42913129386cc823e19c3b3"
