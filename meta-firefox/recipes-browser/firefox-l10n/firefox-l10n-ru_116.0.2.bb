# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a64571bf4e0046e6e3c3c34ee28a7ec"
SRC_URI[sha256sum] = "4960ea20fa7e9e7e2088b354f3f78124af458e984f7470fcaf4a82c1d8ac9596"
