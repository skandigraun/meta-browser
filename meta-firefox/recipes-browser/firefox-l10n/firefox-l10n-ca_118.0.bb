# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b51185baca81c3faf461da772779ded"
SRC_URI[sha256sum] = "d05c222a4085455d178b5ede71356044ad00aebbacab25ee3342e387441a5509"
