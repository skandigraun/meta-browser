# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ff9ad11c0d295a02e5864326a15b9be"
SRC_URI[sha256sum] = "22c6ba57d1f6688075e71b68983d13636c66daf6feb8c6f5e36207572e26b7ea"
