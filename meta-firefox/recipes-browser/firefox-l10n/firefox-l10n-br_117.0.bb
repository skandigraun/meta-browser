# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60d8ce0db40be0564da261f01843e0b2"
SRC_URI[sha256sum] = "d1fd9361b0ac0e1c15aa78ba1cdc5b6958933c575eba0eeda96e2c0faec7412d"
