# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f7ac1dd6e9e1cf56eeb74d3fe96e99e"
SRC_URI[sha256sum] = "fb5bb80c1857b33f36186fc65b39515352c92e329c30a252ca0f5531479cfc1f"
