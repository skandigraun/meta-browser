# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "117b2b157d7e89a252a69411049d15b8"
SRC_URI[sha256sum] = "a6845c3293db236e4fc3ea193d5921039d8495131a01d670b8a801e8308a3560"
