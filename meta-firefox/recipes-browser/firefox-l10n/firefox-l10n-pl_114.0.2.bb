# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8998501ef70cd41ed8f7a1937b483c1"
SRC_URI[sha256sum] = "99946c3eb5dcd34e4f62c0a0a945b74a0084af47ceef16c542edfb3c540e7121"
