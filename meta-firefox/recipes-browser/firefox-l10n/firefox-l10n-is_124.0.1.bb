# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb243100baa71e9402493a5c231f185c"
SRC_URI[sha256sum] = "1d73e18aa7e02c1e3d4a50c59c087b5ecdd39a8a40637dd8cf27fece383f1ee7"
