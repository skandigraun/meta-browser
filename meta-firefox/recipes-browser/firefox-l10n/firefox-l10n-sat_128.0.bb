# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e25b61d07110dcd4babea13650f0554"
SRC_URI[sha256sum] = "e0d73bec3fd4e6b010a5fcc45f119691a5e30a3e9db4b04168b6689cd2e8b42c"
