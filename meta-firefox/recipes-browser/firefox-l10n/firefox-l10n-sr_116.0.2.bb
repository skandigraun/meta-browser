# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d246ad84267c85bc71f30e2a09b7821"
SRC_URI[sha256sum] = "0009ea3d1e526af6164274b02dacd4cb0eed9fda831c0d9a6bbc0171075ef26d"
