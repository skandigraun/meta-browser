# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a857e5fed1b69b69404ec87eb718011"
SRC_URI[sha256sum] = "e0145797c5e9c9e473248272764d0e449993c0294f1859d23157a27ed1ca2753"
