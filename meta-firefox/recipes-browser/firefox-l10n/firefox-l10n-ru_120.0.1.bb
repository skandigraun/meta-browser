# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a28b4054b219eff655898d3973b9abd"
SRC_URI[sha256sum] = "b8edde5f66186635cf8dab214ee729302ea07b53ba601f49f4e8883d8cd6c02e"
