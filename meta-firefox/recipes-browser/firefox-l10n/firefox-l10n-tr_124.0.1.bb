# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5aaf647122e513d6cad7dc387dc5a8b3"
SRC_URI[sha256sum] = "da4bcda0540967fb5539c21a65b02e57b4d311f145a7a2635dc61383258ce226"
