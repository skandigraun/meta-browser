# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef99661509a0ed15c2fa9759780aa3ba"
SRC_URI[sha256sum] = "bbfa5609eb95f7b433f8765e9efe0b82f60afc4a451556f06051d186bffd2bec"
