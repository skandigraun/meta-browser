# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2872b24dfa99cc94923a337c4e0ca83a"
SRC_URI[sha256sum] = "b4337ebb9648f4d8aeba81287aa8b5753f314a11e7f920adbf8bbd8d63239e9a"
