# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09b7e0cc04adf0167a42ab9f42592fdf"
SRC_URI[sha256sum] = "c0da5cd1f6c57b2eb19ccd6b916665375e032df9d17fb7f99a1e5d818d505cb9"
