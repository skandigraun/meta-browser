# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "334fc12022f5add9ab5bbb2819d9552e"
SRC_URI[sha256sum] = "95d28e9b40fdca3ef627592e10c87744c3f74aea886f33385b4e8a7f57025e61"
