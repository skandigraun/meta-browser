# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2451b7972ae4c0a6b5ce1c759c4f49a"
SRC_URI[sha256sum] = "acb22536808b946ce701f045e0d6e4ef20d3e084da249d4661a0106ab4a28a77"
