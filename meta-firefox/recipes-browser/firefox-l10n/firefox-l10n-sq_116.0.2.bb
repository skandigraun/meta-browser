# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab8bb656a0b29d5cf9dc19ced9d5af3d"
SRC_URI[sha256sum] = "ddc86fe49eae57d522832ef156d0e6c5ec3f4236f5699c502bea0f95383f93a8"
