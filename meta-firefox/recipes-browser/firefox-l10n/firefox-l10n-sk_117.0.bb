# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd05a5d97a2f8086a49b17005fc18ea5"
SRC_URI[sha256sum] = "05cde338c3616bd4cdd6e8c3606a77dacc8b84b0c873594c7aa9d716978086a0"
