# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e162e535d552e167658e517adf8aad4"
SRC_URI[sha256sum] = "c954e1db3b7700ac0ea7882fb2efe24251444979aa49bc8f5f3457726853d33a"
