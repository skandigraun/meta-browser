# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33be38b28b0390a6b21dec996b8040fa"
SRC_URI[sha256sum] = "4211d36d1757847d55dfd9e623f94b732f4b41e9c848775eadc3d4ed2b3d26e8"
