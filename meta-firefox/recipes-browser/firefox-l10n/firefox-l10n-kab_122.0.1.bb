# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56234158061036a4f1d024fcc6ee9e00"
SRC_URI[sha256sum] = "7c20cf6fa3f96567818a89d2c61804d33871b0940e87d954d9c6665c7377d87e"
