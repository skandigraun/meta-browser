# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "128ec47315e6085f1cd8fd145f2b2cbf"
SRC_URI[sha256sum] = "c0e64ef29250ac885c781dd5639f2379b125b9107bcb72290627ed5dfa17eb82"
