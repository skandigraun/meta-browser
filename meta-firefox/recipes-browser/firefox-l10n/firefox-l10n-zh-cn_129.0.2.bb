# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eac52e0c3e24816b7633e7b7a06bc38d"
SRC_URI[sha256sum] = "c896bfba5cddc731c78e24d7b2600e7fb5930100cbbed03219244b7ec446baec"
