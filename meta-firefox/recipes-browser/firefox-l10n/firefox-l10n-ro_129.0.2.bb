# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "184b1943717944a707c9214523e32923"
SRC_URI[sha256sum] = "d4fdf87623028437c46f7176e2e20e01ab60120ccb47a10c18a053f4845edc13"
