# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5a9185ff200b9d9f4216b177f6e5daf"
SRC_URI[sha256sum] = "f4f3939c508824768ad3b6e4afd4d4772ca69fd945957ffacad83fc9e566e250"
