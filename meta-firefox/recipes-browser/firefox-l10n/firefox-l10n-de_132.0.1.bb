# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b1749d1e45f6d10cbaec0bdc8e22b73"
SRC_URI[sha256sum] = "d62f1ba45f8c7e2b5f066041531bbd983fddb1c53ddd2236812bf55c919dd1ff"
