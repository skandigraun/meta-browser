# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16deef4657774ee29c3ad8afe34098dc"
SRC_URI[sha256sum] = "200bc92a1c0c2b19ee9fad7394ea08948885e18e324a32c4b9ab764aa28deb53"
