# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56bdfea0d6940418a2c74c5b8d525bd4"
SRC_URI[sha256sum] = "92a3444ea135d8535c2a57a372826fa9fa18bd7b3ac7c3cabff2e40d231805d1"
