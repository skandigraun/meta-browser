# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7b973b0234d8351ffa13cb03ce603d9"
SRC_URI[sha256sum] = "de93478dc7d4e1d1f301197558eecee3f0858bc194b9d09057edc3e57dcbb113"
