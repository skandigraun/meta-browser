# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48b0a0520dc8fa901f97b52f576dd45b"
SRC_URI[sha256sum] = "be63d30130ca83891ed28c5b5734b55d3a45b7675ae1f5dc9aad088945d91171"
