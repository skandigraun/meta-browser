# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f621c7e920b08600964ca02ee869d3dc"
SRC_URI[sha256sum] = "e521a354533b1306a1263d2f8e96c1f43d6e64b2436edbb1b7bbdb050dfc3f14"
