# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "089d4c2f9905c917007783f426bea89c"
SRC_URI[sha256sum] = "e8ed89fb1a1722f41349fcec9201eec1f69fa0d46c1144f46332f2cf7836ac4b"
