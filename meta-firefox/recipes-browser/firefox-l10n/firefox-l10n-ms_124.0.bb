# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9bb068571b037ff49d2ce0d135eec75"
SRC_URI[sha256sum] = "c17b71745a140abc0d2fb6cbdee20f66927ca232282cf6811be735c7266f7a59"
