# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89169b2a8579975fb5acc9fb3681b1c1"
SRC_URI[sha256sum] = "30caac387cfb460d984fe869445b4ee94d9e105f8cbea6b110c98c21d1e25316"
