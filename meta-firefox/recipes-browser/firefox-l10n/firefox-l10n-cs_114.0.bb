# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92ad465f3d601ffb6c669bca4a78a518"
SRC_URI[sha256sum] = "d0f973e086135861ce2e5e26e1e56bf9b21503d06fb732c8b918f426d55348f6"
