# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3c2eacbd7e997bd58e564544463c299"
SRC_URI[sha256sum] = "adf3585824c1e3ac129034bde91f4513abe08a4eabc383562030017e9a7445f7"
