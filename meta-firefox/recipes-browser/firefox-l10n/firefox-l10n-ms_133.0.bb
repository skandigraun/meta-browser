# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ef3863be1bc8eeb39ea1c157cff0479"
SRC_URI[sha256sum] = "de502c7961e4e93847276211d26e747e238ec2ff77d3418e74914052142b27b8"
