# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6e32bf70525e878619bd46cd257e41e"
SRC_URI[sha256sum] = "30c36575c7938fc64cfa1342e915517239e1897499610f4d041dfa3b1d30b84d"
