# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab12b570953c14eccb2cfbca9b7877d7"
SRC_URI[sha256sum] = "bb0d44769e96dd85425e36d7e647931cc4e4bae0d81aa83cca5ba422182cb5d2"
