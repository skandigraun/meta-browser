# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aed5d6aa6b88203756ecade731a2b25"
SRC_URI[sha256sum] = "0437697e3f25170299be139eca646352c839d835c41e6f62963f9ee1307066b2"
