# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea307b746d42188e4ca6ed1d9d6e7a4b"
SRC_URI[sha256sum] = "fa14912e2aba1c26f6cb537ce5237dc786e3981ab36e691fc7a9212f993c734b"
