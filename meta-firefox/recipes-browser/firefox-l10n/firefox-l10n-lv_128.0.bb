# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bef0d743b9f5729d4798d692d72ad481"
SRC_URI[sha256sum] = "571f0af2a08d3b42ea2ff3b80a06646c0f51e11bb4573d01d31792d7f48f1512"
