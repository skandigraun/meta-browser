# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93bb2bb9e626210b7ad361da824e0255"
SRC_URI[sha256sum] = "481ad0320682e34be489a9ee17c330aa385551c0868e0d2a403854943734dc4d"
