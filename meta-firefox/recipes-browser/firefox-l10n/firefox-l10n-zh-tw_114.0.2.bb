# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b6e4ef632dae6397b455467d91f430b"
SRC_URI[sha256sum] = "e6664050b7228f8a630e2867638e85f005b56f69b7a09439700ff8896f010a49"
