# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3f91fb64b3cbc32b5cb93e128234dd2"
SRC_URI[sha256sum] = "6b8f445557848f6ccc31c16e77db229f0e346aba2294588e049457bc7893bc56"
