# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5dfe1c1955c4f1bd3c85ab9139bb869c"
SRC_URI[sha256sum] = "097dbef829f673f25efbacd60420753cc45caf7034090ce38c26a8d7266b5152"
