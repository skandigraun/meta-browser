# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa1ead22390faf79a862d88068bcd796"
SRC_URI[sha256sum] = "e5654f533b0ba282a7a679f539b324898084fe774f86799ec3eca81c501862a9"
