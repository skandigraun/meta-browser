# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a6bbf49b0e8db51e6afc03457f9a37"
SRC_URI[sha256sum] = "4001c841ace551b03ffb4222046a678532f1114a824fe8f612ed372a20ed53f4"
