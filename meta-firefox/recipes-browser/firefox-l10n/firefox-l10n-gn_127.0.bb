# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b025e91573931f997e279fa0f3a811ed"
SRC_URI[sha256sum] = "74eba902afba4adf478d9759df82d23fe7b3505871e4bd148b378766318cd57f"
