# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6047959b4e9478b1ca66715f8a4d35f1"
SRC_URI[sha256sum] = "e3920bc4cc054b55f2536b8b28eeb9ac2ec45246340ba438bb5ccfb969e9d93a"
