# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a2ed6a1f44daa7d5591643eb605d6dd"
SRC_URI[sha256sum] = "9f5e8600e554e39b9edb947e712842774102c42d58c9ea98e09fc770e83e15d9"
