# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62a3d8ebc6e41cf807831335717dca1b"
SRC_URI[sha256sum] = "976a308a60945d98f90ac4f59d1ed4f1d5673b8974cba5cde5861ffcf2cb093c"
