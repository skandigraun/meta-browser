# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1b80f8bfe1a13fea9a25c18df7bfb7b"
SRC_URI[sha256sum] = "48ca8c3bb94e87a23462a8dae089af846c883a391800498ff28ff68c68bbae75"
