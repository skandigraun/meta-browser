# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "506ed6dfadae12b97abcb45bc40aa785"
SRC_URI[sha256sum] = "9968b944d324b7de46e17d9aea4cd5086ce2240d1a33fd2aecc651ee871d5c48"
