# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4da337c6daece4bc199754ffd2a69840"
SRC_URI[sha256sum] = "cac28273fc26ab25dddf9d41cfb92dbc616f74f6460c5adb71d7cc78ee5870f1"
