# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b59ad498c1a892f1c72c7d008517facb"
SRC_URI[sha256sum] = "ea5b72df6443da8aaf2f01020cd1a43e64d49b551bf801941f35847891fb36a7"
