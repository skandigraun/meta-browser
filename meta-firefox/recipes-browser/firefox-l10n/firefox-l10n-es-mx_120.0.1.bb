# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c79d0dc5aef66bececd8382dcfd66421"
SRC_URI[sha256sum] = "a12643796393abbb3f3da05bdb75b558ef318c0a4a8f607b93f3416babe09f7e"
