# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c33d13279d61c4ed36b14f58464e8a4"
SRC_URI[sha256sum] = "2c5d9895d86921357610b9d83e88b858eb126e69ab35ecf7bf7675a0b7bd0b30"
