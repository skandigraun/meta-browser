# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebb968ad5e62c57746da0c79e864169b"
SRC_URI[sha256sum] = "2d0515f72541c23628c34779dd2344370ccb114c65f5e93d9d5110393e62ba58"
