# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c2d1cc3e251e62ab03c68751589e723"
SRC_URI[sha256sum] = "cc4769a1372fe19d1d64afb2660d71eb012f518a731fe2a3b1fc4d38cab285f0"
