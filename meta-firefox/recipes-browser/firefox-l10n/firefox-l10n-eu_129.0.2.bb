# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aa6c376fe7e9594cdebf80a93bf62e0"
SRC_URI[sha256sum] = "33aa4760a16c4454274bbb809db7e2e6f924647015cc45a2747bdd1698b69619"
