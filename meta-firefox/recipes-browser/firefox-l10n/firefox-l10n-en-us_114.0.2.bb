# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffb0709257218396c5e37ad0c2577610"
SRC_URI[sha256sum] = "98928fa6ba999b409f7efc08bd8d83340774a0e6d3810be295502cf3c821a424"
