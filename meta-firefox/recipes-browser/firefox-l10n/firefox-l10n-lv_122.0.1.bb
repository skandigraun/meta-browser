# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83468e30571594d659ee07bef6e39ac8"
SRC_URI[sha256sum] = "4c5405b13dcb477a88dbf69284cf2be3419d800f85f8c6db1ca2b345ff1f99e9"
