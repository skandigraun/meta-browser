# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c53eababf1fe283c3c2421ad0168b7b"
SRC_URI[sha256sum] = "2f4b205860036a5b67bffd27cc58ead8f4a3a2e15e3c2cec9e0dd2127c010db7"
