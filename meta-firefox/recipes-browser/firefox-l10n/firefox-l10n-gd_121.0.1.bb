# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97a4d791c858ef5a50016dd418133371"
SRC_URI[sha256sum] = "f00165f0924c85d50740f084a2c66c7c1cf15446a9bac7d3a27e38543348bc99"
