# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d476a6107280519995ae511a7cb098ae"
SRC_URI[sha256sum] = "6ab86262140c7437533edd81cfacc73a1c93c01f43698314ca6155619082aa22"
