# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9fa49e0ec35d7df431a3b34453ad53f"
SRC_URI[sha256sum] = "0bf33bfd506c5f753c767470ca4fd798a2f8c4fb5d00b7ecb15e378f4902d67a"
