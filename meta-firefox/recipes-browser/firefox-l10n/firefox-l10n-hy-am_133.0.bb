# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea9630726393b8f4122ab7b6ffb65342"
SRC_URI[sha256sum] = "0f0ce8cfce02daf457d29a93000185218318ab43453791e30571f8fd1481ce2e"
