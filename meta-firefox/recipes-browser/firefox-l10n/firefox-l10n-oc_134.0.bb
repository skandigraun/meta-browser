# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d80e74413912a1535e85b66db235b708"
SRC_URI[sha256sum] = "a634a4d82fbc0787f4732146e65228ea6b7e1a3b9cfd86a8a0a3110b71372391"
