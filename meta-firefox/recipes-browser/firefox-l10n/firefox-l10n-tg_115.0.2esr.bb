# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a456a3c767eddde727bfca974938b821"
SRC_URI[sha256sum] = "e4616d32880ed8c607b3c20cc29a6bdf410cc802f8dffdffd27fa52b1808dde1"
