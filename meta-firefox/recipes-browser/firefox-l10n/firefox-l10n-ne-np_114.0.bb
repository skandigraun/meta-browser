# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "259cd739a06da634dd94b431456e2b08"
SRC_URI[sha256sum] = "37cac85f7af9cb2edc726cb8336dead32ed2f10ab6e72547c799e0dae455148a"
