# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19ec3a4ae63810a398bf4d1a6e4ccb9f"
SRC_URI[sha256sum] = "288cba0960bd0551e6b96ab66fc52d2cb11ca4ca0fadf5fe0e3eeefcd58793b7"
