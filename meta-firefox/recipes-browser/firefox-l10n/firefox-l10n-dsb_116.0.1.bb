# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bca2882c9dc6452ffb4c41a4b8da87a5"
SRC_URI[sha256sum] = "dd0e58bb6d8bd3d33872ff9895300c5b5ec4f7645ce18462013bf23199211fdb"
