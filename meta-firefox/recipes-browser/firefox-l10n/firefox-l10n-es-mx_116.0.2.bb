# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fee45d1b6a85fef887ea4d1283d6807"
SRC_URI[sha256sum] = "fe3a39e74c1f94f94014c69c2278162e4b262d1ef3c60a928e919afae2df18cd"
