# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c6a5a046dae412daa3ad7eb4317d7a"
SRC_URI[sha256sum] = "dd0b709d2118c846aa1e38eea5c6abe1942d976f840e636a8e0743bd33da43cc"
