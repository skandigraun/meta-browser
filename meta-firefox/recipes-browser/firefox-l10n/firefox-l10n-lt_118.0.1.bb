# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "602e2f88e09fbda132dbd85ee043543a"
SRC_URI[sha256sum] = "3d9cee8238ca419ab677e00e14b07760c6b19d776c15bb754a1ed1d294490adc"
