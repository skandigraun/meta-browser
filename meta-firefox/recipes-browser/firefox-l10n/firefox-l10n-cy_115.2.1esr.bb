# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f4db49e6d66490a652d80025611ba3a"
SRC_URI[sha256sum] = "ab8db22d487011cf9c94dd2a148e12e39ebeea81be85490c06b585ed23b44176"
