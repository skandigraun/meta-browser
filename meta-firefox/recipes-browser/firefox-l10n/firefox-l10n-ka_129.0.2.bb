# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef9566a03e54a140a0c06054aeec6917"
SRC_URI[sha256sum] = "c3e35c5125bd19a3d90058b08c7b696b37887cbb4352846b34874bf8ae64d8ad"
