# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66f5261c1c7e1ff5f1990d7c9a815123"
SRC_URI[sha256sum] = "cadab8a6fe547e796695c773a9ac1f280aa0ff356b5d80c0b77cc151193a8d10"
