# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71fe57f0948d8f273a297a332642db30"
SRC_URI[sha256sum] = "d1cd4a1481393b99f24e5223a12b32f9f73629d2a6e5fe4c0ac9e761bd6b7834"
