# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a22909a7eb4366887c1af3583b48c846"
SRC_URI[sha256sum] = "eadd57f54c1eafd29263d26c88dd46bca4147d896a30c534cff50fb243d76f5b"
