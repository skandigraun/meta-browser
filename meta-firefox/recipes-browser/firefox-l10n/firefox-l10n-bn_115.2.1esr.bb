# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a77faa4f7d56bb1ceae96bd9a8d91aa"
SRC_URI[sha256sum] = "e21f8998a8e40be2fd532c6db1d2c0481dc6d4c5a76f5571ed8224a127dfe198"
