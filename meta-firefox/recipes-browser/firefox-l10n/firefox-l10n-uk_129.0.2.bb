# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "020a6b8870b3787ada5f2bbc4ed003d0"
SRC_URI[sha256sum] = "ff71bf0a160a1340acdf7bf4142cfbff56bcf77dd1facb5d65d211e32bb895f3"
