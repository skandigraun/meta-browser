# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f8cfd13adc91aa74709cfa1d967ad01"
SRC_URI[sha256sum] = "1bb0c2b1b6563901fc980ffb60c7556963627c8e0139f8ed6a7614911e79592a"
