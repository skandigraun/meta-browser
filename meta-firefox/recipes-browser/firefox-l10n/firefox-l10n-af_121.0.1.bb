# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "224e2e5e50272378a7e8626aa1f9ce57"
SRC_URI[sha256sum] = "f04251b589d80c0e7f24ee91c0082d4b0aa65f74adf66f156bc78115a6832bb7"
