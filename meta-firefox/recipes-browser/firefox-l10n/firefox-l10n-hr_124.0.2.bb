# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60311b0707a8e4494d4adcf7e8bac725"
SRC_URI[sha256sum] = "c128bc6e74e49a12aacd00abdacd2d1aee341e61c7169b98eaa5857e54a34d8a"
