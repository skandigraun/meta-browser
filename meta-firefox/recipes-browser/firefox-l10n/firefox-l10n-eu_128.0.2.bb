# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e0e717e4dda6b3ad2707df07e047dfe"
SRC_URI[sha256sum] = "99e224a1580a73506c6f91eba541cdb402781fd71653a6393120125d0a139e17"
