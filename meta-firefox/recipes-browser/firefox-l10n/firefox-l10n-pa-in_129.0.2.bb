# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3666bdf39c8c96659c28a2aca1907b4"
SRC_URI[sha256sum] = "9e4bcacf1fc001b2dc32e2aeee0ddb85c4a21280db4a8a8955f700f77717bdb7"
