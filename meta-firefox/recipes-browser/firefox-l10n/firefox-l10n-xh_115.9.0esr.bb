# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb604c90d01e1c4bed69905e74da29e1"
SRC_URI[sha256sum] = "464b9cdea6bf0d8bbc945b45a6b829990f992b7234afc88a3b8c067a4b6c2def"
