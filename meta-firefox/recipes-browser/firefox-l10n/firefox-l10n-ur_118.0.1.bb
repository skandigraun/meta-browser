# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f60896401c0664fe177ed4aab2bff3b"
SRC_URI[sha256sum] = "10545f42d702ce6d73e80dcd7d32f3cdcdc5954a55254ca49349e48abe11a556"
