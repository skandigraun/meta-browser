# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ed5c94c5e0e650bb2df78d44ad80abf"
SRC_URI[sha256sum] = "2baef8f164b5d62cefa4aab4d3536e0237899beb70b5715f35f61f58e1e6d46a"
