# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "628c10541fdc876978ff414348e9d528"
SRC_URI[sha256sum] = "2b6c6badf9c37c57bb1119786e506ff6fbdeb550c413103c3fe4836df100f830"
