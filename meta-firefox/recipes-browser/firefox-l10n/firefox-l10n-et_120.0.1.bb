# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc7ef5c1eab7933ffd970d29003ea3c5"
SRC_URI[sha256sum] = "3015eb7c10e653671f7b1a622c33fcc657de0c3688375984fe682496d1ff4572"
