# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cf5290a522bb44d4f84fcb77e21fe64"
SRC_URI[sha256sum] = "99647b6558b588313c309910e59ec9cfff580b8c800783d51de9bb3b41140723"
