# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57826665d45c5c9674a7d5362500bee1"
SRC_URI[sha256sum] = "ee20d490212c90dc222641f6f682b7feeb58678b5ae1adf171d31a0b001462fd"
