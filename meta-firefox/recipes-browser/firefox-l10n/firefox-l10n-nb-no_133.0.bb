# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f38c3022ad43a1457ab1d470e6eee1f2"
SRC_URI[sha256sum] = "59f078aff5f87e6ee3f20ce3e090339b4939ef6d48135fc3b66d57f35eb01a8a"
