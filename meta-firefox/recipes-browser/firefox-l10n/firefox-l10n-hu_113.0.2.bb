# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a432bb852d22c449d769ea4505b52dd"
SRC_URI[sha256sum] = "dac2033fa837fe31d65eb7e35ce5e7e7409480d1ba8554dada2b78f05290bc7e"
