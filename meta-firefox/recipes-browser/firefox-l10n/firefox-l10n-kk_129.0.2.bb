# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d72dd9768b231fe6a0981a77a59530a6"
SRC_URI[sha256sum] = "116392566a92bb08e9412a138d405f397dc5b95f23dfac5c6e4226308ffa9abf"
