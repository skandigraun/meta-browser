# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "321bb2ae99e6c2a036799c34ad860e32"
SRC_URI[sha256sum] = "e04a9b717351350ff9d8107bb6068484ee575496a4b4e5cc98adc98b76c79fb7"
