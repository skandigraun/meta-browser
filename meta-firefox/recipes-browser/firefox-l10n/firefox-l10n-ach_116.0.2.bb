# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceddcfdeb4adf8c850ddb929ec27798c"
SRC_URI[sha256sum] = "65aee490efe4858fef837f55350caf8dfc26a5c9e2bd954bb2afacbdf53c103a"
