# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "087f3d99b3ada550d4820082128f8784"
SRC_URI[sha256sum] = "0ac9b1e3ab7cd70e6feff0a3669caec13c529ac0d4b169bf7948b6cb31cf78c2"
