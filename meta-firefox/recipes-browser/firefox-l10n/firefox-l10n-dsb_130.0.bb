# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd519514a04dafea69fe309a83c1c08c"
SRC_URI[sha256sum] = "98a053bafcba83c2d78fb8826c1e437443af8fbfd3df7ecf9815408a79ac0de4"
