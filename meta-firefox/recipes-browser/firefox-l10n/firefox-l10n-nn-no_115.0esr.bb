# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4d8e767bc108dbc80fefb05b1d91752"
SRC_URI[sha256sum] = "474fcf335d2c916407e8912a177383faab7e9c9c9e4c8046a0d32fb305905ff4"
