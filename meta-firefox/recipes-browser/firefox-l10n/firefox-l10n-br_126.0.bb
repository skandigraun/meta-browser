# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b53f07ae3b6b6767cd304c4bc203c0a7"
SRC_URI[sha256sum] = "ea7c41521481d0cec6d50254c1882ca3e88d593c22c6526d0a83c08903d379da"
