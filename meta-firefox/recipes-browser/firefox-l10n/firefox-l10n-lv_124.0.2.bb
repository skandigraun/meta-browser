# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2eb1efc7e6ae7aded445e08a7e00d7f"
SRC_URI[sha256sum] = "0ef3fecbf00c0a1a17ac4b369b34fea55ed306361fc1f0b39c7eb38405a14db5"
