# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "870e9fea52f5b927a23f1162b1422a23"
SRC_URI[sha256sum] = "caa11e817bc2b4979ed74ffe8a6bb15e8fb2e429716ac430e74810e351b85d28"
