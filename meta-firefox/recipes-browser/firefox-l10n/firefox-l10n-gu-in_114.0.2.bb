# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bd2de405b28e3a75911eaf066a4944f"
SRC_URI[sha256sum] = "ebdcfa0ab54fc98b439587cfe737a7ec1ebcd4d22a4fdd91803a7060d5452dcd"
