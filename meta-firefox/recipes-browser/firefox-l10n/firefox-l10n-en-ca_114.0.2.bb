# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31c0c8909560db01c16812c337adfb9d"
SRC_URI[sha256sum] = "0fc481e53e3db9db6d37c1bb3bbf219fa8740051f7285f172effe5ede9346c69"
