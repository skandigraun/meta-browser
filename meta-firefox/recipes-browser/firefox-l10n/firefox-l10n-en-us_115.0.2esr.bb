# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4c896fa74519eb7056b571074048d69"
SRC_URI[sha256sum] = "e55033b6d8dcc9c24e99bb8ad93a6399ea0699a07cef6176aca86c4cae0dfc03"
