# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "decb1208491c23ff90790be735ea1cb9"
SRC_URI[sha256sum] = "f8d9f77a923fca4acf8cad3f75e86f5d81725b00fd63f53bd4264ba528beaa8c"
