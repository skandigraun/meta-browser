# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "002095d0535c0f5eb57216f1239ad55e"
SRC_URI[sha256sum] = "4d9ef092e27df5c0da908bcdd501d54be5c5c4a83f0902cbe10d42bfdf1931fa"
