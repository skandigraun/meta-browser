# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6e201df931ab14b7319de486c8363d2"
SRC_URI[sha256sum] = "512101e3698ec7762e252a96a1c0741527760c9da91a9780a84950d3319da444"
