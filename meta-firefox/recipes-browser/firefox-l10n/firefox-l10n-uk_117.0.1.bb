# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e58d2fdad0c16771b45f85b6bce48ad1"
SRC_URI[sha256sum] = "c806b86e3d33d204eb2e63c959111c942dd6b2684833399405d612ea16d9aef1"
