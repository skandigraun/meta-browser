# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "913650c73c004c5e7bbb165140c9afe9"
SRC_URI[sha256sum] = "8c903eb973d8811be09a1f5873e3418a3f78c13e8b206e12cef4ee29b2a0a181"
