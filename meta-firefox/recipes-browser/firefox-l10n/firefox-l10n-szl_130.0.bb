# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3cd41e7b3d003240f32684314737f6d"
SRC_URI[sha256sum] = "ead26fd8401111842a894232de967d35f384aa80079c6ef8cd677626f2577868"
