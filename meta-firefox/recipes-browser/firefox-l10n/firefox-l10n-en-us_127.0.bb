# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6270a39d29aa88255175897b6d554c7d"
SRC_URI[sha256sum] = "0625b245764ad00e94e94c87ab96e7763b1cb1248f93de110406afee9a33ec57"
