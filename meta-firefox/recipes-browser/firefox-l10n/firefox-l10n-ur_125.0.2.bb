# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6f90c728c441adea1e7a5880b1ac96f"
SRC_URI[sha256sum] = "b640bde7cec2c4b056de333d078240bf475720c99f702f3d1f67791e4502af76"
