# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70bbb0b05fb86268996906128d298d80"
SRC_URI[sha256sum] = "3faf1450821b549e8421decf903cd917c6c0ba51f5d073e7f288f817eec1d278"
