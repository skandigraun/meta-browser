# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d0665e4aab5e5917a99ab54a28c990e"
SRC_URI[sha256sum] = "26250727aa639923a4f945dc038db67d7a397e9e2c0a485818eb30f07e41840f"
