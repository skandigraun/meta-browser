# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a5666fed34dfdabfad554c464415ef0"
SRC_URI[sha256sum] = "10ef12b0dc2875c6eae092be2f704cd8806dbabc5c8947efb704719c2758d1d3"
