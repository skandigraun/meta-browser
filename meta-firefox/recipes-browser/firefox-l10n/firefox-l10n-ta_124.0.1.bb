# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74d0238b73ba615c799168d33cac5fb8"
SRC_URI[sha256sum] = "524a7826ab60c1042dd284ded377ae9330007968e2ec0a1a16596c740e51dafb"
