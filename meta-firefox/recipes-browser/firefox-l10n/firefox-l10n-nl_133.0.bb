# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "475a48b7890c38d8d8b7d88e6cf31ec4"
SRC_URI[sha256sum] = "0394bfc00e6d1e9c2411417823138025bfcd9e3e5457cc1337b4c6ce3b2937b9"
