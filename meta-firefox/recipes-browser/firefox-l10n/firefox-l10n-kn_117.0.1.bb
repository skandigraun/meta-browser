# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d35cc372b5d40dbf88466304c4302d6e"
SRC_URI[sha256sum] = "8d9dc52534bed570b7bfc394b7d9bd7be12039359f6f674c27515de279289879"
