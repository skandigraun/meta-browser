# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f57392c74140f07be6fd43e6b722d82b"
SRC_URI[sha256sum] = "b2a281bab750797f8c2f78e37326c76d0ed659ea3208792e0ddf9c61413e7edc"
