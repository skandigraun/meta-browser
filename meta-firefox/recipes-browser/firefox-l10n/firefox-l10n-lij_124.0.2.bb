# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51d4f83e159b4b7b1daba1c01e9325ac"
SRC_URI[sha256sum] = "01eca2c25dfc64f4f4adc117ef0dc8719b874457916f4a0150e89fab4a500ca8"
