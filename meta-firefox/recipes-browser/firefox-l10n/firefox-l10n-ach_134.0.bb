# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5580c2fb114128c81df291dea21a08b"
SRC_URI[sha256sum] = "ca6f48f598c50ca32edf23f0ef101991db82eccca54d5d8c497a1681f96dc932"
