# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b85775c0f06b005ea5346d39b83d7b5"
SRC_URI[sha256sum] = "3577ad797274e11d521398e51a279cd93c15f41edb5b6712a7beebd69dd21155"
