# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "530cc470240d8af2772a6b0a0d3d6915"
SRC_URI[sha256sum] = "92f1b4fab9422d144ae5a5baf231869ec33169d36482dba956decd618b00c59e"
