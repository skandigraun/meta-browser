# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf6f964841e23744cdf0d3cf0c2ce0c4"
SRC_URI[sha256sum] = "0b549db9a981647c6cdd168e2fe46ecb4733adc9e741d6b1488e4d20c36a73ec"
