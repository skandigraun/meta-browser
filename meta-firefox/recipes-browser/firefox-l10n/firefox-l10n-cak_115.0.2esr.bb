# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb9c47ccd7b5756c986c3da4eafd9bd4"
SRC_URI[sha256sum] = "a90d56289c390ad7273be3f61f200a1ff6715c42edc0a15798f63c00009487b8"
