# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e263626ef07dd1c9c72a5f23f00b68bc"
SRC_URI[sha256sum] = "fe67496dc823b582ea0c0a547a47c810e680cea201686b0eed11274c017c021b"
