# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d661d64f34244b7a8c36528dfa8c0328"
SRC_URI[sha256sum] = "626571318fa294747f09efb558491aad82324c83656c6680369bb4bf21a5a15f"
