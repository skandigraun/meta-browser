# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e023ce4b3c942d230e25c04ecbb4f19f"
SRC_URI[sha256sum] = "47f7915d48331b71885e5945aac127aa0cb6080563ceec38e52a9cb91852477f"
