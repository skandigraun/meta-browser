# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e65e7cf37fb556f5a46ef78c3b8aca50"
SRC_URI[sha256sum] = "7b337b5e42fa2a1a3f3e5728f8c3c1af92f49de43b6e855d9bb0f7f0a01731f6"
