# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae5a25a7064aef761dbc94e28760e859"
SRC_URI[sha256sum] = "07287313b8afaa1742fd81d7c00a38136df4dac8405576b5798c69fbd275b236"
