# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a191a4c6031211689e74b88b4ba794c0"
SRC_URI[sha256sum] = "a00637b08bc79b2c5e8156cbc7b43596f03df26d95fcd4a828e9ac42a120f740"
