# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92062c301ce65463fba7f21c25de9598"
SRC_URI[sha256sum] = "082aecf12ad0f9e513d6656948aa1ee9b072c941c1da731d048d81581b6b5bc0"
