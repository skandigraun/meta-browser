# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa9374380f73282601045672f8e68fd0"
SRC_URI[sha256sum] = "ab518ea7d4bb7fb9ef58f0eb7363056766fee21c002a25b488dcbd03271297fb"
