# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8865973b54b78c2b5cea9ae3b84cb1bb"
SRC_URI[sha256sum] = "63292884ea971b0528b623533bbfa9a961eb6576d4ee33bcc70dbf7aa5cbfd49"
