# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88701190a7c62947a5e1479106821219"
SRC_URI[sha256sum] = "0a2962286ce075a08ed9f5652feb28ae341aa085c4b089baefdee740dd0ea605"
