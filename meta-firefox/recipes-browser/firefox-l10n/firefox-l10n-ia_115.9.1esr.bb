# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d97de6397a86067d7d1c2085319b6cdd"
SRC_URI[sha256sum] = "7d0ba3a1b61b0a10aac19a2853c2fca02ef0026f91c49a45e44d1984b75239ea"
