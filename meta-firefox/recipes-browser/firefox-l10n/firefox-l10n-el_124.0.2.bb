# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eae8b953bce772a7163d47bd5fb7f1db"
SRC_URI[sha256sum] = "bbf622e1ff5fe89e03d31ec8e20c61c8c0c524134b3e7df3e78ed73ec8e47314"
