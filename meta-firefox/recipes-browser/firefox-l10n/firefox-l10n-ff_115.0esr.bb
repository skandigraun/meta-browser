# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e49c222df7bb577e20574a079871e084"
SRC_URI[sha256sum] = "a2e5d33fabcd55ac394e533806dd28aade84b2b8dc33f00ec93bbb0be7556e82"
