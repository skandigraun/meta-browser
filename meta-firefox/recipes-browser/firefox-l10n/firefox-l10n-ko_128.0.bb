# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8371d827ee7b008eebc28218db45cb5a"
SRC_URI[sha256sum] = "68c6fddafebc0ec9ef9e699b890bb3fdf9ef1b410a22707fc5a52cfced525260"
