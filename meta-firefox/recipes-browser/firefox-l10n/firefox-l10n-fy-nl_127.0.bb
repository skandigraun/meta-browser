# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2f79a157c7ddd0f357997685d4720fb"
SRC_URI[sha256sum] = "42ad89b39cd61cfe31efdf9621bea3f61b4a2560d3ddaafb7f0f245e8376e6cc"
