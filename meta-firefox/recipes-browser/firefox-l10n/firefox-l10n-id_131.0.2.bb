# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9776329537410ab1673f7cb36e5d18a"
SRC_URI[sha256sum] = "e503e72339898ad9a939395cc649b8041867182e3d066f1e4281fdcec3afc041"
