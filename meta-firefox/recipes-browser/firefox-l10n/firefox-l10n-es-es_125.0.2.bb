# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96c8aa05cb3d23e7c300045ea18f1704"
SRC_URI[sha256sum] = "5814fc7ecdcd01a17c135e2c6bcaa617563deb3b31a3a9a802f9cf85d12c2d98"
