# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28d323ab0cec8cc0a1fd8c409a1025b3"
SRC_URI[sha256sum] = "e2e2f6012ea64238e6224b7b8e575b78d82914e03e5d469591deb89e0260194e"
