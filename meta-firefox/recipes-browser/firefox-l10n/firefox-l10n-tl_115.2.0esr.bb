# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4947e23a7cd22ecc43330088ffd3a02"
SRC_URI[sha256sum] = "1ba1120a6f105753420e90db2e5ba18345745f8bbcee4f655b5c59219824f33b"
