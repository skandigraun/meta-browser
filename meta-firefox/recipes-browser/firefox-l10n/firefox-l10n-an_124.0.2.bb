# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8996b137801b7df4d1db1b89e0f5894d"
SRC_URI[sha256sum] = "c23981359be745bd266c25089266fb9b31a5a854c64ebb593f8d7c6aa684cbe9"
