# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7869cc91296a6bb10edb8394e59fae90"
SRC_URI[sha256sum] = "d70b47fbd36abf2facb7eeb60dec92a14573f96ead60f267a59fbf9d5aef5d51"
