# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2212f45245e34795ba64b154a2b0705b"
SRC_URI[sha256sum] = "02538a0029a6663852f33d734d21912e3c29a27301680e6658ff1bac6bcc59cb"
