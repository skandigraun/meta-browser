# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b885ec0edb0dc2957f72b61e1314e59"
SRC_URI[sha256sum] = "57b0a4638489dcac3f7ee2e41be40b8599d1ea6344be375d761361c0e51b03cc"
