# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc01050c92fd1cc770bcab02afa680f1"
SRC_URI[sha256sum] = "522f39d56822d0f3447554a00374614e3703095fd126f480b27ae7fcc863fef9"
