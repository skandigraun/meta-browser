# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59bb934b538731c874097b0c9db14503"
SRC_URI[sha256sum] = "f1b6e48d943e7cb1ec15021ece7774a2eaea0debb640663df84883cf0338bd8d"
