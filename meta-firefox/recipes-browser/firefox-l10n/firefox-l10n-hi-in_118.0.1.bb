# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "440d3f90aabb80aab301245ccaca2a47"
SRC_URI[sha256sum] = "45169b96c4b5401283a92baae1dbfb82138f09566a9763859b83ee4bb0e35c2a"
