# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ae42e10ba7e815848a67624a4235de8"
SRC_URI[sha256sum] = "2cbfc179817352ab159be1eab5de943326b9bbc3ea6cac533763c28bd9307a54"
