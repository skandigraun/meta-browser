# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d74abc62f03a2c820504341873b6822d"
SRC_URI[sha256sum] = "e58ea4de8ecc1e1361d9641c6edb05bd865c253236f5259f459aed243f885c8c"
