# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8a7e50c093823b8740d59adfd099b5"
SRC_URI[sha256sum] = "7c23f7f6dae8e03dfb0c898b665cc55cbe10b6b70bfe9347ae429fc434563b7e"
