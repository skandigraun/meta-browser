# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6aaddcaab69c7ad3b8f14ec9579dde44"
SRC_URI[sha256sum] = "6bc5e6efc659a52ccdd2c96ee8775447d71972d6e167ce25e79c23cf15befd37"
