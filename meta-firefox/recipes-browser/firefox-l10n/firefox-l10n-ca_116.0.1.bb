# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e88abaf8f682d886956b66ef5ab9069c"
SRC_URI[sha256sum] = "d1a57cf4d301316c8e09f33eafdd3163834c52a237489821b7485fe8d1403fa0"
