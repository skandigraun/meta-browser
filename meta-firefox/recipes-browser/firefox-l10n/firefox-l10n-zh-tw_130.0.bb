# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bff3f1bad2cc9336c191d71eb80b6c5d"
SRC_URI[sha256sum] = "b7c630897d5fb9fc5ec4f6a850cf4a222b894ec3b4a349fa3897cba168160f49"
