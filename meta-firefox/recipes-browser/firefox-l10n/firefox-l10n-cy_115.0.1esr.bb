# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e5f121d6fc063ffa591b30eff167d78"
SRC_URI[sha256sum] = "9031b4829b8432d70bf900336936bbbf3b80f1a89902b532ff076ecf075b44f0"
