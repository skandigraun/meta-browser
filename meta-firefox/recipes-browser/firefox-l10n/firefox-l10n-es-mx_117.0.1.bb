# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48840afad63e8732a7a40cd5991e70af"
SRC_URI[sha256sum] = "ffd0fb461e7800c58504b5d58d0cf31e9a012140d30303630d6f9966c509cb3e"
