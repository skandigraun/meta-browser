# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed5a1da2df8a977e898ad4cea6ad4233"
SRC_URI[sha256sum] = "c0cdbd501ef153f548757db4748880d82e8aab816c6043e04f365f2cf82f4591"
