# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e615d30960eee2eae4d4c57dd5b2952"
SRC_URI[sha256sum] = "8ccdfbe8db31b3cd85e6c4f98518ea88b7e18b9e0d95cf3600dca3d7dc5ec001"
