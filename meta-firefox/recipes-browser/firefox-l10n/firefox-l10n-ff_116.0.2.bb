# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a00a850e9fc27f5aa5e86af247a0bcde"
SRC_URI[sha256sum] = "a496909a77ed65343385b729dd5d6a8877fd9f17f64cc2236acc23cef5c8d0ad"
