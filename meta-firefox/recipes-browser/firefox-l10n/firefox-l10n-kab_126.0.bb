# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f26af6d118d4f7cc2f952bc15509965a"
SRC_URI[sha256sum] = "31d945feaf6a95bd31d4018d7c2c2cfcfb613f10e15ed0dae09a62c4e71ee7cb"
