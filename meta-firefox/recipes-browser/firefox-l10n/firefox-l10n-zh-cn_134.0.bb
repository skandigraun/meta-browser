# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7f103425f73fd7638effdcf3568b1ae"
SRC_URI[sha256sum] = "afb236b43e3af13d1a6c56a4224e695c51b8ddfc6814dc167a3a5c4fd6f668dc"
