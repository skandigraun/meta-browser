# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f824def2de4400c2564db2dfa06b75b0"
SRC_URI[sha256sum] = "9cfb6e70aeef131f4ae50cc2f8d2075ef2db79533eabe0caac760e094a814f61"
