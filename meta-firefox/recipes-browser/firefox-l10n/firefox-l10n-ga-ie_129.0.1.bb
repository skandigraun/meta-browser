# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "776a27eba9391c8cadf8957370de9261"
SRC_URI[sha256sum] = "9ad23f6e3d2f047e26e17e34e1edc0da77219043c7d8aeb7a426f40996437525"
