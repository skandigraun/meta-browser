# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67ff130b645b2700aed3eca2efec43ed"
SRC_URI[sha256sum] = "4731a2cb68b92c7e61f67a45a430a77a7921fe01473ff8a3d4ab41c195c4536b"
