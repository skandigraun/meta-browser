# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9958afe2dbb1dc2f0768277744c47e1a"
SRC_URI[sha256sum] = "24af32b0ae678a43adfa58a3c000b9dd6c51a2395735e06307f2dcc0ad8dc235"
