# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "458e168351939a0a6c3986d224eb67e4"
SRC_URI[sha256sum] = "6b1a4a4ba9e7c6882c2ddce678ada2ae5bcd113543ffed92157b573574457dce"
