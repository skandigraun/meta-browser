# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcf0492de10993cd6d4184b4d4069e3c"
SRC_URI[sha256sum] = "aa6c81f55ae710a258218bcfcd894539afb1371cd661a04e9407c579e7edad45"
