# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51c033f167bbbfd4184d5d3ebdfbc055"
SRC_URI[sha256sum] = "657b66725d8af1be44efc72f5d4576d0125d934f80063218dfd7cae9142f887b"
