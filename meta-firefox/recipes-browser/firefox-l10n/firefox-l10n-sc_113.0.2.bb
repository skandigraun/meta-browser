# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bff1323bfa5e6522223b0a9540d064b"
SRC_URI[sha256sum] = "8e95972ee659b2982e0ce35dae00c3348cc1c1c082b17bce3649a72cdbcb9220"
