# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1184194c829f830356dda48e8d8c2399"
SRC_URI[sha256sum] = "fcdb86d26a9cd92ee832219cf708da1290735d8e42316469c9a3a0f466f23350"
