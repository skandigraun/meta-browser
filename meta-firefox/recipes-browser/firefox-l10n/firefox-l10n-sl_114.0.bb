# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eff44e95e580493dd66eee2f3fd411c8"
SRC_URI[sha256sum] = "ba69da64c6ab3d416759818e420259023a4d64434b27cb604d6491737e7e4a33"
