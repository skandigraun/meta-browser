# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a10c8ff991c13d6389c6c83bf9af2c55"
SRC_URI[sha256sum] = "4f89f1ff215f7fa9e1145b89c25720aa41f99fb42e6eb72086627d682168c353"
