# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "443ffb06ff8ffa91695a40eb925126e3"
SRC_URI[sha256sum] = "ec113b3024363213b18423591ff49e2f3826c16d1efe58ac6a735d0a0d08d26e"
