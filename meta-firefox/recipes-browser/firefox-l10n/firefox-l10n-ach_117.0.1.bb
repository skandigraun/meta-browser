# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e869fe6e757d55564ac802fe5ed9b91a"
SRC_URI[sha256sum] = "01d4ca60796642788faeba2166069769a73c0817d48f0b95037c1ab25168989b"
