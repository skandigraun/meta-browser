# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9aae5ba6f185835e3564cf6a4577e34"
SRC_URI[sha256sum] = "5cc5c08468f41e8df70af9beb407b7ffa8a7fe913f3654d5e7a156d777430018"
