# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8062f5ace1454c615970faf9d241403a"
SRC_URI[sha256sum] = "6c55d7b3ef7dc1d3d1f26e7d0565f2cd32589bcf07c0709e073c4402b57a7884"
