# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "455b24f3e60fb1a97fe572ad71cf7dab"
SRC_URI[sha256sum] = "39685a11d5230bddb14ce949c7a3e1a58505afa03a5fba3a25ea2c199cd1ecec"
