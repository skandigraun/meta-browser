# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c87e3a07a1d9447b07619a5fbb44711"
SRC_URI[sha256sum] = "d4c0dd8076a96a1d11e4779eecfe06cf20dd8705a06035fcbbd837e4a861cbc9"
