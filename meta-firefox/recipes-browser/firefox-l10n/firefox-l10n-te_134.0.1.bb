# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ed5756502ba510f966ae4748094ba5f"
SRC_URI[sha256sum] = "4c1859b082889cecd017d52d32b893367618fda90ab94fb0e7a0cea26600cc1c"
