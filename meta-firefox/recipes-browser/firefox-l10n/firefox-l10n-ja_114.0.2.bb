# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "651e100021718cb824ca3299302b847b"
SRC_URI[sha256sum] = "13058b3b01d8c3c1d24cd60471af53eefddc07829d622261b2300af928ba431f"
