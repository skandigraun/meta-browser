# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa2a93a4970118c6204d49cca69de0f9"
SRC_URI[sha256sum] = "8c388bc2d51a475de125eb977ffd4cb9627f5bb2889fee09001d5282d9bba316"
