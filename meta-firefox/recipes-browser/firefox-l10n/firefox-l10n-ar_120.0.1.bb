# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8adc34b31ae7bfc6bd745ddf45c8c82d"
SRC_URI[sha256sum] = "409a8a9b77bf776a36bd5c874ce78200d2c195209f76e6ee55aaae5c4347406e"
