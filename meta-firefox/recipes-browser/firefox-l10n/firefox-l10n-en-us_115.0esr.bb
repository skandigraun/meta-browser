# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f25528d2dadac0ec0a2a071a0a7d535"
SRC_URI[sha256sum] = "fc028490825a0f7ad44e545e1bd801f7fa2b9e0a7a654e1193dead24a3585640"
