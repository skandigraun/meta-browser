# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "056de53500394c892d1ac0b78b75cb11"
SRC_URI[sha256sum] = "a1388dba905b1caae90c006238628df3a77a0de253fb8f1cf15c8a19e83b2201"
