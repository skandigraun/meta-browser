# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45be175a56c636b9ec8c6e17f6f2c829"
SRC_URI[sha256sum] = "0fb468bb0d0951e9479a5d89c2ec0c4c9b1adc17df0be17b844a3f038670a0ff"
