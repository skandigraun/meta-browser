# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "538c66893b95ddfa650823845225143c"
SRC_URI[sha256sum] = "a3f9ca46af71eb54e4775e34ed2fa9aacab63128fdd9317ae8b873072098775b"
