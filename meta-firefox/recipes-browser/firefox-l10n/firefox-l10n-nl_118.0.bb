# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4d6014db62c82d9a33e44d37666db6c"
SRC_URI[sha256sum] = "52239f1997ff07f0f62ecd59b32d2b1a0fa8131d8ecb09532b92a393156d5707"
