# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aef0ee254c913cface6bbd24eab69220"
SRC_URI[sha256sum] = "e3f910fa0eda590df6b5f31b3452896638533e97c5f5cd20e4738dcce91eca36"
