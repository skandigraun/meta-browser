# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19a7d1f75bf005739ec747fd4ca194cd"
SRC_URI[sha256sum] = "7db2ab3ecb76f5ad0c83338c55feee171aab83844c3fd68b2eb7fc858f76e5d1"
