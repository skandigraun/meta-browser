# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ac7dcdb86fe43a0fbf49488c7ef2b7c"
SRC_URI[sha256sum] = "c0a744e583a75beaeffdce8116db73cd985c4903abd0916ab41d51a131143620"
