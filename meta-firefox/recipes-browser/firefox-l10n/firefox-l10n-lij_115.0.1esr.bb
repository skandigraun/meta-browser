# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "254c07b469ccdf4db015d5798f892e9d"
SRC_URI[sha256sum] = "cabd7710ba4829c0dbd6d9b8256b1ce1eb4b3f1baf9a635e5d1aeaf53f37c9ff"
