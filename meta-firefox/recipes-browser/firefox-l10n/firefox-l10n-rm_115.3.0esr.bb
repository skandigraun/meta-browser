# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aab9386ee536b4016ea80727b0a2bd53"
SRC_URI[sha256sum] = "c34704657ce4acc988d23539e8bf968dba5f14f7d580b212c4a79ff38f5977f3"
