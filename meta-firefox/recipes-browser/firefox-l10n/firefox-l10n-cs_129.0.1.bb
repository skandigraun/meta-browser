# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65ac09b83541321de1cbd80063d1084f"
SRC_URI[sha256sum] = "043dc5b564ec01f20595d6987673e620fd69e59a323caa1ccd9ce3f900750707"
