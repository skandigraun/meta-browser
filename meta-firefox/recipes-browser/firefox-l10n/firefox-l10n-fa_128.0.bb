# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9137fbc6950780e01aa3ea827701a2f"
SRC_URI[sha256sum] = "f79a47f3084eaee63e4e062c853c5eb6aadc15c6f9fbb77560ebe17c141166e4"
