# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee42df6314474b5d75966731036930db"
SRC_URI[sha256sum] = "81224d1e650dbfb6c24c508c2863a0e3b3c4e1ec3e96e25d105afaa372314313"
