# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7824454c63550b3a0155136f436ab76"
SRC_URI[sha256sum] = "53f199f19ab010a22de7d455c7ec847d6abdd64dcb0f0d7cdf28b6961bcf1327"
