# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "356f4b84732eaf7cd792d554eed28548"
SRC_URI[sha256sum] = "76cf801cd9de79b2c14ee14c25e5cc7b1a84e9c335a57dc5be18d9dde5b0f8b5"
