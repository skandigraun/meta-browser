# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac17601946a62f15be0c7c2d3783f20"
SRC_URI[sha256sum] = "4d7f48a19af36afc2c50355d15eff34d0fd5254aab7e01eae0f0a7f5059c6348"
