# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba37d87acb4f21557a5909a18a72424b"
SRC_URI[sha256sum] = "0d4f8b1592fefc4e72b8ab41b7e842b59dcd158ac2215ebd025c135dda296e51"
