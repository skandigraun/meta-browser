# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e80936c855a5d074ac6f7b31ef9f027d"
SRC_URI[sha256sum] = "f49015d4f1af7fefaa2a591a8c1a308fcd19765fe719ad87421e0f0cb1d8357a"
