# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "255ebf4115760f8a6287c59ed10a27b5"
SRC_URI[sha256sum] = "269a918e4a19ded499624262e3c0b2aabb1ac207803cd5545628efa15c22b4ce"
