# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63bfa42c0fb33a3689800aa9e0391884"
SRC_URI[sha256sum] = "537cc0da3fa8ba0b421590cd83d481c3f148e985a00f16a43adc3d21ad15b742"
