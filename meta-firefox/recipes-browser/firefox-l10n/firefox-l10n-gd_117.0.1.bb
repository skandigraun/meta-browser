# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03f460ed1e19dcd30a8f57a0ed1a83e7"
SRC_URI[sha256sum] = "43f697231dc113dad14d817940f7528884a3524544e06c1dc8487dd5e7d1179c"
