# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01a76c56749389279d8ea60cf0fb597e"
SRC_URI[sha256sum] = "2d3044779947b5344adaeba9d7f8977cfd12723416ace62df75d6db9950cc79d"
