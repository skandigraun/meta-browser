# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34bc26e213fd58a3f29b762489da4df2"
SRC_URI[sha256sum] = "31da68ca9d9ff3ad8087cb78ae966196b630dcd42b61a378f5b8bd369b4823e6"
