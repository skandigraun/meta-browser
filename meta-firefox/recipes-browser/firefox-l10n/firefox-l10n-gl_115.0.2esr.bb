# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a495dfe70e26927bb1accbb562e6caf9"
SRC_URI[sha256sum] = "15967a0f029d69b9b56de1e2a1a13a1e263d649a40d35795f4d32bc1157e79a8"
