# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83cd3de296409904f88aa98bb1908aba"
SRC_URI[sha256sum] = "c5d7e74df7a90718b11cd6fa7a5941732cc1d9e76cb63dd4e1c2e5d415820df1"
