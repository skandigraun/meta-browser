# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcdde93b761cd9b71c2541d5f2bcad38"
SRC_URI[sha256sum] = "d697b1b13b8283c5b0b5b84e9729e41e868b3005fb089e170ae7962e028c48e5"
