# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be46d0517081393dbd0b117e1f87f1c5"
SRC_URI[sha256sum] = "bd4b8e333d29b492087b95f47221ece8635b0a99852333f2a82ddff7dc810b5f"
