# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1813a182e3f188642bee0961074908f9"
SRC_URI[sha256sum] = "b0bc5e7460bf7e64947bf1c89083f9efb6104064ac8670e59f0a4feb202c481a"
