# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f68e31744f0e09a38e6adbe7f0ac8774"
SRC_URI[sha256sum] = "3fc7650eb068679d815ec4f7922b70779344da0043981935b4e78019738cd811"
