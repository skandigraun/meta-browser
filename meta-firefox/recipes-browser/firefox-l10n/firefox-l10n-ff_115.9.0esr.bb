# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bed31f1b660fff5e621cb7fda21cfce"
SRC_URI[sha256sum] = "8284ef1e1dd1774ed1de00a24ccc5e5dfa396f6481e8f95182fe762f1f10082e"
