# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91e7687369e1e50f38f21f911a2a50e2"
SRC_URI[sha256sum] = "a9d5c42b1f0685efc12bc3c7ed4b5c988af7a35530cf25af3b682b05837bb027"
