# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bffdd1b43d6d35b2042ad96b1624a15f"
SRC_URI[sha256sum] = "507b3cdc4654266462e0f1b1a9e4754f971f95b763f2baaf48c59f2f7ec7e5cb"
