# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7fa654f2a39dea22a32af863f3a55c1"
SRC_URI[sha256sum] = "50e747ef5e9f0e6c1f025de3b08742fd5856f8c93f34dc9275e319f3e1de4a71"
