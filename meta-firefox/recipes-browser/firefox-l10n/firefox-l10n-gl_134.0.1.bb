# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4fc3e0ee56bffdefd2b3f8f7b8bcd64"
SRC_URI[sha256sum] = "b046ae3ad193ff5136abd4aa78f871ba34c5dabc9630d27b4f06dd56d9956f5d"
