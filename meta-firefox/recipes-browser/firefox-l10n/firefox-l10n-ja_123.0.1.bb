# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "462b8d38584b80cfebbd4f43cf9d5358"
SRC_URI[sha256sum] = "dfb1b9c6e9f04f8dc0ead39ab62e3306e39c752ffa9d1ff14ec6d193949669a0"
