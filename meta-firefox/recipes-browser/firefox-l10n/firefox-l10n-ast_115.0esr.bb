# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9710a995499bdf69497ed85ab82a1c9"
SRC_URI[sha256sum] = "7e2158ad6e6edacd317f0d7a111a71051b220dacddfa6437d2d4db9cde9eab2e"
