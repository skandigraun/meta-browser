# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c705ff97c90d7e6c1d62366418a6f1c"
SRC_URI[sha256sum] = "4098002157d141822de67caae5269f22c0adf1f6a47b76bbfef07ec9f52275dd"
