# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61e44f035ffdb692f1a9ce503dec7533"
SRC_URI[sha256sum] = "7356274b193b334f1435e705630814abab65e8cc9fe26faffbfd1d0ff40cd2ff"
