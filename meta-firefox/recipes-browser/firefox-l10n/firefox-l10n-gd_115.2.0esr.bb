# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f57624022429069834a9e3f3c15db456"
SRC_URI[sha256sum] = "2bd5b94c8d269061f1e1d471a2ca32677ae022fd38387a9ad13151f9d1b039ce"
