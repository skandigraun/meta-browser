# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b783a6a0b570a420c84630792cba3070"
SRC_URI[sha256sum] = "8b60698ddfd24c9a13d3b28fce4f303e02072fe0ff2f1d011e5d0df68df84f21"
