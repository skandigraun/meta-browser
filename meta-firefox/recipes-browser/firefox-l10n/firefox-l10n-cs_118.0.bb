# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22c3a987324320f8a8efdf8e8a5db528"
SRC_URI[sha256sum] = "55ecd9b2db08c065286070205ef6981791e5cc2f606f03414b6d6d902e8d875e"
