# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "910af75908e9ced92834cef3031ad02e"
SRC_URI[sha256sum] = "592c0e710e45c9810880d007c800ba6fd503d340d1dc90c47f81d4803f76776a"
