# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52b8e74611396663232877fe2aa37597"
SRC_URI[sha256sum] = "16890b038c531c1cf7feb85bfee434a6167fe71746183e253fef07f2a8d5a8ac"
