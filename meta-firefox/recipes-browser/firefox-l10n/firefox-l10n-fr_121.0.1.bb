# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fe010c9c0ed29e526cdcbfe5c960f51"
SRC_URI[sha256sum] = "755098c874ae565aaee31aa1fc548f2e0cd17a23c890fc83f67c0935a6180dcd"
