# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e42644d8d43caf4f87ee11f601e1a227"
SRC_URI[sha256sum] = "320262563037f6b1563cae31b02a1f75b011e79a6aa0a2dd205dc1dad9dcc1bb"
