# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0005e7496604954aee9f15199983531"
SRC_URI[sha256sum] = "72097a82f6946f9b2195fc2931c3678edf61e813301698dd6f9b8d2e2f780e54"
