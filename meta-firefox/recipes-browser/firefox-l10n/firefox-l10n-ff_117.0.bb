# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd6a9b3c7d91b217901587ed5052f255"
SRC_URI[sha256sum] = "d211378b142409709f314b9fcbdc8492c5a98730d870e98539907a4384ebb758"
