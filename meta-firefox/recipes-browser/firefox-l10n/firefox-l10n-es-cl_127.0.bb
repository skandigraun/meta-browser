# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "472a79f8b0e6c19174978057586e6650"
SRC_URI[sha256sum] = "5573bc543cbcbc1b6b5dc597abeddaa82153ff3c041c6173bc6aeb6594d79511"
