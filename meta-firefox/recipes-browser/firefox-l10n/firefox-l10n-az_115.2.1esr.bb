# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0c8b3d696a6ba982f72725726346313"
SRC_URI[sha256sum] = "01779596d8f220c878cdec904c5b4d27c7399a3eba14106e6377c51afb4f55e4"
