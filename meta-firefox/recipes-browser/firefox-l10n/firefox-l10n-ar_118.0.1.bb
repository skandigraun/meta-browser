# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a78e6b05a92099bc8d622825453be03"
SRC_URI[sha256sum] = "c98b7299242e8200c89629f4b9af48dc3c15480db73996cf84afeab2a2090d75"
