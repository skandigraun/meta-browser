# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "601b0703a5f53270fa9343bce6d2ab22"
SRC_URI[sha256sum] = "7970c39ec19ec09c7f5eb84aa12bbbb76f9180936cbef71bad8770ecba4abe1d"
