# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7439926bc13578388fbfaa0d5f3dcda5"
SRC_URI[sha256sum] = "3e04f504639674566c2d305b63177d948021960ac20578f42e6cf89b2091f172"
