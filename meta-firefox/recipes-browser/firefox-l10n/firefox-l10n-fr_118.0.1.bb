# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593fa877dc12191df79ee7a893086397"
SRC_URI[sha256sum] = "23d3672bcb2dcc15949ab01b9e1a1046eb30d16f9c6ff220877e6460bc8542c8"
