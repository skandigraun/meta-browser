# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc944b7a2a6335e464e343e1c866b525"
SRC_URI[sha256sum] = "7aa5d68b6c027200f19f6861443fe3e063115b22ab84d1fa402eeeb10730b3ea"
