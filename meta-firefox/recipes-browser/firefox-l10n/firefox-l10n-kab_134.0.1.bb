# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df751583f28133d8e911ed2c71cdfebc"
SRC_URI[sha256sum] = "37cd8719d62d2506706c8dec7eb45663c82ebc7051b510dc80f2f41fcb3f1a9e"
