# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daf184c6986ea60e149ab8e0379d2de3"
SRC_URI[sha256sum] = "2d7b5860ddec91296c8abd5e232a9e78ef849933897ac63d4218a0ba25d58022"
