# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f376a6ed6af2c9f5068d87d999a7e8c"
SRC_URI[sha256sum] = "95c03cd4b782a96db5f6a2ce69d09f558fb444f1f8ed8f6a7ecd3bcf6cb4f7fb"
