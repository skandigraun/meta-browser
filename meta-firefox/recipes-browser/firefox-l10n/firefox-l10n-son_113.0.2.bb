# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54698a00f1972cb14f27e952db5dffb4"
SRC_URI[sha256sum] = "f6948df8e04c4b10ec6ec2d56b34f7bb4975c83a069fdba162a3499ece0d426e"
