# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a4e422783d32bd4875c22acc592a0c9"
SRC_URI[sha256sum] = "89ce382bbabc4e29679063126a52c483aa0b44ef26cb12cbf820e55fb06c05f9"
