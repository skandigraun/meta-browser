# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2a7bd9f08771a10d4e72af50cb88097"
SRC_URI[sha256sum] = "49db1ab5340aa160fca8c884f79226501154f5304e667dca5ddd093663b4173f"
