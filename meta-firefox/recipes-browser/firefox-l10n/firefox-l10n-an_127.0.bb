# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2870e32350a8288f4c6db1ea9c64e344"
SRC_URI[sha256sum] = "6e2b8b513e56d79894b9bd390da656e4e726ca197314063c66f25420ee7d3570"
