# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7aad38f9e08469f61428da8a56c863b5"
SRC_URI[sha256sum] = "883ecd146785b7491cfb41dde53208c32c7c4f50c22ab0342b81c21820727baa"
