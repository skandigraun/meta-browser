# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "606a57a44bd309a0de1915bf17925bfa"
SRC_URI[sha256sum] = "e177f26fd823a1d0cc94fcf6ac89323b4e2d2245d32544ed136444d6475efa41"
