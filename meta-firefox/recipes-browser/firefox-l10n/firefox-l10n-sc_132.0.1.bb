# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6df4c3d41a9adfae8d36ce010db6bea"
SRC_URI[sha256sum] = "95d78e19cc4977c7a61d755a983690cc7b029d2ba93fa935747ce06684cdd9eb"
