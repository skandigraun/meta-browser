# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ced8aa680af60fce2d98319556e9a8d2"
SRC_URI[sha256sum] = "aae383b30f8ce4a2131d59f4ee642149bc7886a06b68e8fac387746127437ae3"
