# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6b4f41a084a62b40658809491a90b2a"
SRC_URI[sha256sum] = "a273fd2b2d715b31904f644fb9750f5404c6dae9982d4cc95db9f4d7a6fe892a"
