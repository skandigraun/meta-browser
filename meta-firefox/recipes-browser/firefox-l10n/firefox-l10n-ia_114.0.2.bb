# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efea2ec8fa424d7ad8c27fc31c4bfb60"
SRC_URI[sha256sum] = "d382995bb704f7c965156bc4882237206dfb3d7490e5bbbce6f35b1c3953caae"
