# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08e4a85cfe11339dbebbe9622c7989a4"
SRC_URI[sha256sum] = "bafc813c7b88611103f9731c58f689b15e6577388b8e16ec297d810c305defa0"
