# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41fd9a656f1781674670e3ff8365bcc4"
SRC_URI[sha256sum] = "615fc6f4a67d1192d34611b3b1efb2a163f0c85ba9a3e4b9a5a80f3138800cbd"
