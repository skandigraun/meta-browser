# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ba39da3bbf6ac4331a1410541562af7"
SRC_URI[sha256sum] = "5a1c2235ea06affae5ee5ce2da7674fd264c59b644254ac8d8caab6896a3db14"
