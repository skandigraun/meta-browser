# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d77badd05725816e0b51903477428202"
SRC_URI[sha256sum] = "038cd72b5a50b13168c7d2060dbfbe18f4fe6d648ed86150b9f4e89fc9d2d076"
