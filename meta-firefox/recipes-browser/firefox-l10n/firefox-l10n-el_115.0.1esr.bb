# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56d09a39facce953774c6977abae76b6"
SRC_URI[sha256sum] = "8ca02c02e89a3239765a709a6c10902047ba32b7681920e7226e7fc13385dbeb"
