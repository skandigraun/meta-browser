# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12816f7f4420977208f4dda9de1dd80e"
SRC_URI[sha256sum] = "98fe0684361be0ba63eb095687118416d3e0ea9d8d9cb8b070f216c34f65a971"
