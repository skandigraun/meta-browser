# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "795b500e80ae0a711da27c33c0ff38c8"
SRC_URI[sha256sum] = "a56e52f472f516cedb06c1093d518e0f909da5476254974f59b8dfcc0710db18"
