# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05cca6486973783ba6b755d59057d716"
SRC_URI[sha256sum] = "414de0f81ebb9cf0e8945200f72cba3bcb4cc05315ee4fbff4e3e7490adcfa61"
