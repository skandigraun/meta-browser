# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b9256f0942e9c37721108a29db45a6d"
SRC_URI[sha256sum] = "12058c3d35b7c3f6ac753e5466378b043db71c07175e034d5511f95f79cec55a"
