# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bdf504f7d43eeafd60496ca076808d6"
SRC_URI[sha256sum] = "a67a6140e1312a36ee1e758698e86d19ce502a13685bb2759d18f309a60391b2"
