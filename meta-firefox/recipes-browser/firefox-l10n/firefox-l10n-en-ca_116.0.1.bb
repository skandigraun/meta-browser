# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb1639209f40188df54471ff36acd143"
SRC_URI[sha256sum] = "2c446738faf5f6b7a2d0f845276fd1929301a007d443d7bbede93a979910c175"
