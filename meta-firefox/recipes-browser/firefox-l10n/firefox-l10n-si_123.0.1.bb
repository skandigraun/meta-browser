# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da31f3d5d5a5d92969d34ca823817ba2"
SRC_URI[sha256sum] = "d5403259cb0f2448317dc0e5544694a0a12c4f264ce5f1d10ed6571e4fe67eab"
