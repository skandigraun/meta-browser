# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4337fb01b2a103b9a96abefd8aadfa8b"
SRC_URI[sha256sum] = "2dc02b822cf76c4617c667572d6fc25325dbbf7957e3a87d1c4059f1fea837b1"
