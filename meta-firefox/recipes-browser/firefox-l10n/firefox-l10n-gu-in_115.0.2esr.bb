# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e66ae4f4dcedcc1d2b47224a2fb631c"
SRC_URI[sha256sum] = "c8c42f544da1a54400a5871e51cdca609572d1444c9adab5859b6b803f27b6e1"
