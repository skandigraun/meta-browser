# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8aea4e7f18357c202dd643edd0198aaf"
SRC_URI[sha256sum] = "180b1f77a30eee16568bc621d05f86956a5668c76a17b227e64b5a6e3e8d7ae4"
