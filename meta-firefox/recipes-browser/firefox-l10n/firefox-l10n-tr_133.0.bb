# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06143ab31545b2fbc95bda102553fa7f"
SRC_URI[sha256sum] = "b198cf75713766c43929289a0e6a8366853fbee6283a6f6a4780f2ca228479ae"
