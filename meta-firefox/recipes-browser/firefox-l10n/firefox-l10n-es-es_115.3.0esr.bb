# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d60dd62b6724a49d11a7eef66f67d690"
SRC_URI[sha256sum] = "715412890b148f3dab6c1a6cf47d0ec8730ad8fe10734578466681d17b3785c9"
