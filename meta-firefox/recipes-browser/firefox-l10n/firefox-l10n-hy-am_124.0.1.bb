# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57c81fab6ae2c0e134d8b5e702ba1d0f"
SRC_URI[sha256sum] = "aef0fc8c289f1febedb4649bfd449cc3c75ac6f98e2da6bd1f7e7f0d358c56a1"
