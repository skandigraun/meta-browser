# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69a71b8d9a15ef7f4d3f74457858989f"
SRC_URI[sha256sum] = "717120ffb3c2113422605b6e2183b270797c377257eddda19aa2f632b1d5bec3"
