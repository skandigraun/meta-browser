# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8d06b931154bf16576fbd9cdb6bcc55"
SRC_URI[sha256sum] = "d3948ffa673bfd59a526b6540c93d6df7203c4ecfaa20a7a684060ede96a96c7"
