# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7669ade2987dfef027a69641cd883f0f"
SRC_URI[sha256sum] = "a6bc17d0d8052140bcecfbbb04c8585e5133cda06f48b52ba7477ff753f06f42"
