# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b95c5b73589483113068c19872546fa4"
SRC_URI[sha256sum] = "56592ac473dda34868e52d5979d30fc664938650ad5c71857dff10aa20e13168"
