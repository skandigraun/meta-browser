# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "478a3abe193f35672967193f97fa8d69"
SRC_URI[sha256sum] = "ca975d083f901682e131d8a0ba1850020e70eedabae23729be27b61e523e4760"
