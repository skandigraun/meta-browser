# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7d52124baf1a69115dbe4bd4555efd"
SRC_URI[sha256sum] = "14e963bcecadd591ac8877896da65b20fe4b0dae3a03f917cc7f9569d0f3a861"
