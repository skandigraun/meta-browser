# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33def68f41c02c219c316a8dfe8acaf2"
SRC_URI[sha256sum] = "7c5fcb3589dbedee491699aca8d88b2ad914db00425a3caad8a2c7e6e9efed15"
