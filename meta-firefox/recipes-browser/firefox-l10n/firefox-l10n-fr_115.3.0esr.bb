# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46eec816526c48beeaa8ee7a03d1e9ff"
SRC_URI[sha256sum] = "9b72a23d48cf304197d9d76293e9d2847881bb285e74c7033efb277d97521e88"
