# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ca216b3a9c4ec756d65fd5cd117efe9"
SRC_URI[sha256sum] = "dd9960b1e67548df19ae5df0f50f975216b988059e739216d2f1c251b949cad9"
