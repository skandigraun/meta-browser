# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c10dbca7637f0bde50ab0bf695f1ee8"
SRC_URI[sha256sum] = "2cfc0d395610a9df40f019875b3fcd05863ff44f4888b68bfc878d7537545190"
