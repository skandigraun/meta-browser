# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9430bf0104e0c994153959595f39264"
SRC_URI[sha256sum] = "e07d9f7f023083ea19f8fa8bea4c5c66967af5e4b397a5bb8fe2c0f45f6ecedd"
