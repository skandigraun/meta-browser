# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae444a76671c4e711d55148e194a01fa"
SRC_URI[sha256sum] = "fd73de87dce45eaa1afee5d76b9401c0fd9dcdbe65929722a839dba7c580c75e"
