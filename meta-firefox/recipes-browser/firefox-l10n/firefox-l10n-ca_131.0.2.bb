# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "979617bcfd751ab12cf233687d66b611"
SRC_URI[sha256sum] = "2e14d08e5f4646f6a247ef3441ad948341f86115dc477cdbc8ce26f4b918844b"
