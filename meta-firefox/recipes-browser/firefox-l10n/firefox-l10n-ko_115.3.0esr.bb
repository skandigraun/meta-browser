# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f3aca9d28ad70d2ba015cdf842482bd"
SRC_URI[sha256sum] = "c35337ef6154fc682486b2e3015198a3c8c871022f39f9b3e594d89a608bd9a1"
