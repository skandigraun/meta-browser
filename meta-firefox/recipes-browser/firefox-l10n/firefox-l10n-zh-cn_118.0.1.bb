# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cceda53de467a98e2052241a6d01117a"
SRC_URI[sha256sum] = "32f46ef091afabcb4b893e1e801a8cd3f7f2071e8cb71e494b2511f1ab78064f"
