# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b084b068fcc5b5eb796afd7e5f451f3"
SRC_URI[sha256sum] = "09e633a44d73d7bff33c7c141d28f0507e9821a978af8ac4ec166f10f88fa57b"
