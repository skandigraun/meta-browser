# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c62de28db45fcf42b8d26415b82def3a"
SRC_URI[sha256sum] = "e3232220c1ea5fdbf013b4a46ed03296d9204d3c511e59ee905f8db078851c52"
