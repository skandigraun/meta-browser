# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b61e34ad2b5a02785da1c2c224bafec5"
SRC_URI[sha256sum] = "c27cf503464c4ef3d98c69b99eaa6b6eee926291ad2aaa149f2b86133855bb08"
