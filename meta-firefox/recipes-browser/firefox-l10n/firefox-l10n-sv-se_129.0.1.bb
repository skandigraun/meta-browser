# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7870f1e8be403f12e022bcf969c93203"
SRC_URI[sha256sum] = "3ba95767e7f09efb02f68f02486846721f036440dfa63dfd527bd8968f6485df"
