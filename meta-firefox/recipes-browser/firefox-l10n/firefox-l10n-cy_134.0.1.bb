# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "664c30e0736edb39d4d14038235d1d60"
SRC_URI[sha256sum] = "add8950114d590acc8e198d7b0a1229cd7c58c04099022892ab530ced0c6b7bb"
