# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9febcbc874f4eb30229dbc7909101151"
SRC_URI[sha256sum] = "c9d36bf320aace101c7776247df8b19797f70e01ffcf41ac25b96292680d46f9"
