# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9f4fde4e61690ec827a72e9cb749cac"
SRC_URI[sha256sum] = "0e91e59781d001b9568d6235583d1535d4e68aaaf1a31373caab13416acb6de6"
