# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9952bc6e11c39fddf02cbc8dcfa9951"
SRC_URI[sha256sum] = "b59755060c08eeb81e1c4c9c5ac8b89cdf43c6206a17c7af5a6b8f9817b9c848"
