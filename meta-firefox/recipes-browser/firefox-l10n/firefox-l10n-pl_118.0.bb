# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "57f24f1aab9acde01d8b6071954cd21f"
SRC_URI[sha256sum] = "2c7e984618b4803be1d560fc9b39963d01aa0fcfcd0923a11724c52ea9bc6f01"
