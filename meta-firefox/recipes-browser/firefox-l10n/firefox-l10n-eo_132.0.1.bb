# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0de4ada4038103cbe6ea846ed6901606"
SRC_URI[sha256sum] = "58a1c0ee331850c55a7fb65a709a90551c9cf024397393dcef208999efe6a5c8"
