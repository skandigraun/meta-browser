# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae2ffe45bc12ca2a3810e6591a09e08b"
SRC_URI[sha256sum] = "a97db5a27893ebf7b33c7cd16a9e1a1d44cd1d65de70be40a14af14a1f5d1415"
