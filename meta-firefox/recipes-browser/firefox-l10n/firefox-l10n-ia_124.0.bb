# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc42a583793413b600cb16879ca4aa05"
SRC_URI[sha256sum] = "a8c0d1575cec158efc4290d12976315c387a70e64d1a5a7317216c50c3982ae1"
