# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e9452921e01b576e645285bb5459ed4"
SRC_URI[sha256sum] = "d58e46696eb7393632e54a4a1a7bda5f28301fac4c76829a38d1e348a64f58ba"
