# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96f09ab3612d1b7896b0a41609dfbfcd"
SRC_URI[sha256sum] = "d9b08619d46a23cb5dbdc3b75c615a0b61abc61b662b6593a8b0a2765e8f1fac"
