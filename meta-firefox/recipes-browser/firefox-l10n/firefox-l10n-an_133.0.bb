# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "180dddf4ff88ab7f8df0f0439327718f"
SRC_URI[sha256sum] = "92eb3118c20235d68315d4b2665f84eb655415ba6fa377d6d7a246eb56c70ab0"
