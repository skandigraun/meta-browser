# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f612aa1de1e7950fdc44fb8db2de368"
SRC_URI[sha256sum] = "2ee95ad872f0ca276446010dd6317c2757934bbd10b7dd22a717d59af5a29479"
