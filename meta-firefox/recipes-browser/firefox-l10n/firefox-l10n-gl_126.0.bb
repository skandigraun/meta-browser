# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df503f6806406f6d2050fa7857b7cb8a"
SRC_URI[sha256sum] = "37146b7d9dc623e5718fe26fc57e64a79ac7970be91f16dbd5773151bcaf35ab"
