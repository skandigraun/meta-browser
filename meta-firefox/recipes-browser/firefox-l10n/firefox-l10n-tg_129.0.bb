# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "313d6ad61ac546e8fdcdf476c9eb9abb"
SRC_URI[sha256sum] = "e153578eeac4c04cb55e93cac29bf9950bd535d4b6f4e8cea2fe2bac1f0746ff"
