# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7937fe65e23015d16f9f4b4a18b5aaa8"
SRC_URI[sha256sum] = "d6bc337040f9bca4576850439ebc900a90bb101d55e47ac6b7493c570d555c80"
