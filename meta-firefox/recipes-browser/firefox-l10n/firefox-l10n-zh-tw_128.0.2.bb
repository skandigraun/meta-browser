# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c4bc7bbbead828599aec605faac36d0"
SRC_URI[sha256sum] = "ca99f5b396c2c964388097eac0d550c9786e7822d98eb2ede3ceee85b34170a0"
