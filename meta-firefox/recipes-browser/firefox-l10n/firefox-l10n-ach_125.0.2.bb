# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76cb49d3585cf05a31dfb46f861683b9"
SRC_URI[sha256sum] = "0e02ef1656903a2b7c6a044cebf0a2d4b8e6d325aebb52a8b5f14c3176acd07c"
