# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a285a9b721af6678b8123fa36bf4848e"
SRC_URI[sha256sum] = "652dfdb21e4d5123f4b99e78e7c3e05cc65d6937c7c039bdcbf7e3762b40b1d8"
