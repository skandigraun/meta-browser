# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "994c3196a7b35f4174d9168c49ed3f0c"
SRC_URI[sha256sum] = "ed1e91f0edbf2325b4f907cf716b4bd3555f5aba3d9c3179e5113922c37da1a0"
