# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ec15ce447e41ef2be81b93ead8a8450"
SRC_URI[sha256sum] = "8862db0693b21f996ce2f18fa2fb4dcf00fad0f1c81fba493b2c5a0bb2c694e8"
