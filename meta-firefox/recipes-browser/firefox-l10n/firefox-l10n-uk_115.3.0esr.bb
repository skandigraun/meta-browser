# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f64148ef9edb236c0757b80a89dcd59"
SRC_URI[sha256sum] = "0ede4f29da97d16c142438e305c67c0b2be15eb673bd954cf637eb439297b7bb"
