# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "612857b7950ab96929c6d1828f4e65f5"
SRC_URI[sha256sum] = "47be131dc5d43839181e3b2542fcc2f35e4f3c3244f32e3468e673b80389e76b"
