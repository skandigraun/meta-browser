# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ebd3dfdad94d8191212056f51ca175b"
SRC_URI[sha256sum] = "53df21fd36ea85876d444c33844b32e0c21787a95ed0d97e8f5628c19d8e9b75"
