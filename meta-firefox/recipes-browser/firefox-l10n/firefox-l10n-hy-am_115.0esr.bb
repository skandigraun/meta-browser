# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9e5b2ff635991b2b4840c7ed7ba03fd"
SRC_URI[sha256sum] = "6458df53e513016cc609ab5b02d216fe312ffbf64d02aa7101fbc285a298683e"
