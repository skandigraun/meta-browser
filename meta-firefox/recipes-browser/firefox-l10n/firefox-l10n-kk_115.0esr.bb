# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7438a4ac051dcaf7ccf24caccfe172c"
SRC_URI[sha256sum] = "b1dbfd221c4b1124e6e22bc5d25db14fab25559462a92be9ae383cb9e77c9868"
