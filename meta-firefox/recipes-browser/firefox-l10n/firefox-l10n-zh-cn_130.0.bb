# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6081659f85ff394285d45ba2ad74e9d"
SRC_URI[sha256sum] = "bdfd151e04ce4826252c736948adbcf8cd441682082ef933b1aa204bef7deed1"
