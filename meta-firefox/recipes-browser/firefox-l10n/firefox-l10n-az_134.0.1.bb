# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a77d1243c57d48887342bbd6e97cbd95"
SRC_URI[sha256sum] = "e5c9520e0aec42f7a87173e873b09abe6f74d757aaa78a19b97646a38ab20ef6"
