# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c586601dd35be4cfdd04e23d665464d"
SRC_URI[sha256sum] = "e7c96c5a5f9c29504cb40c17ddbb0e1ef93de975151b10d8dfd5f9dc39b95f6f"
