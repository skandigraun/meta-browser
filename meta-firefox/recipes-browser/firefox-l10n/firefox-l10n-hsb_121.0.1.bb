# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b85106913cd429d365349bec1d06e66e"
SRC_URI[sha256sum] = "04a6f4424466a8804d9137683becb8fecce0b5f8c03c9370d604e2c62630f74b"
