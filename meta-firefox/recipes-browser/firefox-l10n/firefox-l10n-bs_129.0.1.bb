# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c939b8a190f74cf2d21e4b584a79fccb"
SRC_URI[sha256sum] = "139446514a81d05f0f47927620a2834b12b25d88f7e1415edd4e8a62806cf604"
