# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cce8dfb5d21c4227c370ea07f1b1cdb0"
SRC_URI[sha256sum] = "d5d061aeeb8ccaee49d92429f3cf4468efe8e15db5769af50be3657600d2f158"
