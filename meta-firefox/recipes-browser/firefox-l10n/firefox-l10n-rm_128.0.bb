# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1e902a6ef1a21dacb5e976a9a9d04b3"
SRC_URI[sha256sum] = "249ce0b926eb449813f4995560f85171c3cec15612b5f217a21bb8cbb2913e46"
