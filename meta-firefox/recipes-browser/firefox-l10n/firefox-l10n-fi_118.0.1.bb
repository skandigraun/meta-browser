# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "397e4121b6c17718f1960d58f8f1d5f0"
SRC_URI[sha256sum] = "debb325b2bec3c943e6242b9dd715170328b7c86f864403541ca36c8aadd5c20"
