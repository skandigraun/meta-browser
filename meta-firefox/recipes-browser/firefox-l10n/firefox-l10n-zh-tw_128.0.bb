# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dbd1542666347d86bc0d0f46e0d0d73"
SRC_URI[sha256sum] = "a8d5dd25cef64aba996e61a889af6cc9e25125f17fd948fd4e974aa8435016ce"
