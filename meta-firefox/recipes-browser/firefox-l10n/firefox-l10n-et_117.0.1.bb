# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "349f62f901de4026d8c42d8540402259"
SRC_URI[sha256sum] = "fbf861ab9d84ad73c863707029b7ccb7b636cacc5e11e18e4819321e04fed96c"
