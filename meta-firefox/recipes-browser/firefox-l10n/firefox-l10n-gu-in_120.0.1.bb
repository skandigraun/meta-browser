# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d31ac2cc53d92c5ae0cab64db548fd76"
SRC_URI[sha256sum] = "6b09332595295ca6c3874c0a3df735defd10a3d3655ddaef1427f501591e80cf"
