# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9a3e8f6ba6e62035494a3f77c354e86"
SRC_URI[sha256sum] = "fc5e0b80bb4dda023a18d46f3f686981a13bfb364d6d29e4e46cf1f58381daf2"
