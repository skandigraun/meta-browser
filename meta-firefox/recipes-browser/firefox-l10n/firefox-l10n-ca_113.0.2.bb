# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75b8bb40ad412bee3df96761060098a6"
SRC_URI[sha256sum] = "6628f487b57822263048038631b3c9405681044da28c2a45c149b78240ca6c1d"
