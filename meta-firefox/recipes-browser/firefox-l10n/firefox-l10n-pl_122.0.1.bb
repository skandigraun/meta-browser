# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d673f83ff0af535ed9e60d378357cb0"
SRC_URI[sha256sum] = "8f50b62e3256b7b07f44196f770e37d0921f1426b4d6f6f9a36bf6bee1ad5036"
