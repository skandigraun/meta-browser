# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "302db13fd0d94a4867ad3911564dbed2"
SRC_URI[sha256sum] = "486265c53cd2852f4cf0a117bbfe56a4dc2f3b90cb0b827b716a4daaa2e42c77"
