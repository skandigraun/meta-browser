# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6deeff144f49974fb3efdec69706ae4"
SRC_URI[sha256sum] = "85f67426d2ebf61e37718fad82d84870591ec23472cd7c8a241c8bd4b0c15d54"
