# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a4b9d1c61b860f9861baceb26d71c71"
SRC_URI[sha256sum] = "f06ce4f0b119c0bfa9557a5f3b16b1bafce905e70e55c708133db14c8519c19a"
