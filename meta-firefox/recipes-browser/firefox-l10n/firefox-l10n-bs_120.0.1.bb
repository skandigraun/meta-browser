# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c27a11840831278a6a7cafb052119db"
SRC_URI[sha256sum] = "ade2545c89c1f21ff8eea4ffde60450ff722f898361cb34c88f7d5fdc6ed0831"
