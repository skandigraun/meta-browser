# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16174ed398c284845c17f70741858f5d"
SRC_URI[sha256sum] = "cb823f38c49e6c2399ec889b9eb26021e3609fe54d4e5ea120b0aecaacfcacb3"
