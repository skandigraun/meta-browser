# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb941d838f18ba48d35cbbdc3aaafb1e"
SRC_URI[sha256sum] = "c86c446c602ac1983a77d2a5b4c95fcc01fd574feedebc76e04a1f577c138a16"
