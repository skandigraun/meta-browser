# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0ba9cb323f73a9a665911007bb369a9"
SRC_URI[sha256sum] = "c2a1dd53af8a4caa0ec165f6eeef0bebd9540b7e93c7696771e5ab4f5ca7aeed"
