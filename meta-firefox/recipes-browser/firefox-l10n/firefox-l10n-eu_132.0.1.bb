# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adda2548a22f7c7541e26835dda8d1bf"
SRC_URI[sha256sum] = "49d8ecceb032f12fa1ac0c7af83b978fd0e6920fc712fd7ef31597f2de894a55"
