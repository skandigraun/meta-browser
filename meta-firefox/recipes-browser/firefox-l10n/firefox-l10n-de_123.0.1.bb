# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46aa6c4b1d860cc03e3a6cbe1f70ac09"
SRC_URI[sha256sum] = "c7ea542c2cdda6230986aec88f8930fdb4512d4f3827ae11664d6dc31c17318d"
