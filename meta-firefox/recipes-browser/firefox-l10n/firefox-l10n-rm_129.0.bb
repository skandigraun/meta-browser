# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dda56f93e9387d68d312503c4173a934"
SRC_URI[sha256sum] = "410e125f8099d21e20b4cba46f9e92e57be8b9920b98662a79633fc2c2b98014"
