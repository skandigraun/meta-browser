# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edba8c177fed625da586f97495bc0ceb"
SRC_URI[sha256sum] = "19c10d41409684694ba9a6c16a35d1c9dfb7a1cc2ccb2d9fa4788e94076740b8"
