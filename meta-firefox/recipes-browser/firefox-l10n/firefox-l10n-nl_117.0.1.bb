# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ecf2a087b1b600e2f47ddac5bdf122a"
SRC_URI[sha256sum] = "8e32f6d0ca6864b770629760c1d89940a496744c088f1e40789349ceb08c0445"
