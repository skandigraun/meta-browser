# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d42b1efd09c098b8b28e2af7809b78e6"
SRC_URI[sha256sum] = "2894f555bc57af1ad30332e840eb899417f4c18070024c144a753ee2f833b4f6"
