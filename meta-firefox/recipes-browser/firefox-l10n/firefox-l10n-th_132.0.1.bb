# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96ff4097f6b18578aaa46fb8401f1e3d"
SRC_URI[sha256sum] = "7a117aca021a2f03ea2cc22dad3e9b0f1441ca297edbfe152b4a411270555eb1"
