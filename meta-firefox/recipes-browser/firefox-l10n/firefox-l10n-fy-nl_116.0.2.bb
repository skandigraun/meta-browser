# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a44477c4c12c3b2718390e938bd5d390"
SRC_URI[sha256sum] = "f434eb07f9a98484948b27f83a659f27b3d2756b77882eb9e3f1eec5a36dedaf"
