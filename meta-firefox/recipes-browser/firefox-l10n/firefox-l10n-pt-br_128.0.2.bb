# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6152ea57c6ffb535f8953d9a4f9d1426"
SRC_URI[sha256sum] = "44be76ef03668f96dbe21e952128a825f48ef7a2b60f5e74c5349d2f5f24028e"
