# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45c39c32da2274b89de22ff85e80d778"
SRC_URI[sha256sum] = "cd29f691faeee72d2469539ef6ebf3c423ab58c1fc86ee81d63582aa847de5e4"
