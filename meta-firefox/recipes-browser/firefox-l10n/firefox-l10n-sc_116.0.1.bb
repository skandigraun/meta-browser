# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22c7ab5da0e636a2edf8836bb6c5ffd8"
SRC_URI[sha256sum] = "2a9c113fe38de5fa80030d5519760aadc85fb378f40d62e5f2d5af59b2557749"
