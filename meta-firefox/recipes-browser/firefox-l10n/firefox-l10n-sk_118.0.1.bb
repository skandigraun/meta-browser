# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d1ec1b9d05f17f22db683e7b0de9d87"
SRC_URI[sha256sum] = "fd87e0b266171f0729a0cc42c965b907ea8d1fdd35bbf8c38044237c721bd185"
