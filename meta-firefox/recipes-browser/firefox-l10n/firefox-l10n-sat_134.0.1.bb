# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "856a76a7b991001789660a580f51df01"
SRC_URI[sha256sum] = "8cd79921e1ba3de52a515f342367d097e619d5f66f9f10c03c7bf6b29538ab21"
