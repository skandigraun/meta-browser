# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff2ba98a8838df12c2fc3fa4ef5a20f2"
SRC_URI[sha256sum] = "36deff854ff5aacd467c481998dba5a33dcd36bdb4c4937fecfc8aa913016b00"
