# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f222fff8385586dfbb3ec3b96e1b35bd"
SRC_URI[sha256sum] = "f5afe89fbed111386594f37627fba7e4d26a455085e365a12d5623e7f3bd4dd4"
