# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1190b3d72eed3752c46c08e9714a5cf1"
SRC_URI[sha256sum] = "bd7773f406ccb3632a93441df09d1cfe3a4c94d81e69ff8778d0945e481a04dc"
