# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09af234c0d10b5ea75a5ea8f358befd3"
SRC_URI[sha256sum] = "b8d332616f6b293727114b56455946847d1249535de8d8249fa08beb3d481d65"
