# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ca2cc01824c51aa1b5b00094746824c"
SRC_URI[sha256sum] = "a3f97513f809705cbe295adfccc930a991364d4aaa86cb97cb15dae60c6ea03e"
