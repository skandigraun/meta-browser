# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "408d95add381d79c3d7350c242ab8d6b"
SRC_URI[sha256sum] = "2e0dfd6827182a7fe8d69d31e6eeee081d8e2809e480c8d03364a8b6f809bafa"
