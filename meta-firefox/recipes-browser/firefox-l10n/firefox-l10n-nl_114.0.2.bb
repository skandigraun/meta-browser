# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f10e26eaf7d586631d29d950fef3f59"
SRC_URI[sha256sum] = "ca3470fe2b498cf3fd17802f7918811a62dbbca19f0313dd966981cdbe5a4aea"
