# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ffcb032f349016dc0c6d8547b5e6dba"
SRC_URI[sha256sum] = "3aa827dca7f3c160b2ca98ab6489eda3d9f04fd026e6ae81c2dd700d9bba8e8e"
