# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1328e1834fd53fc56b3cb6ea9977a6f"
SRC_URI[sha256sum] = "4c504cf7692081cbbf0f70d18baa9e5a5aa189157b0f957769d44238f5723e74"
