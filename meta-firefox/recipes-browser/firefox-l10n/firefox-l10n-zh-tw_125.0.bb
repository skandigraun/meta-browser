# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "378033037727ee0f98376262b20412df"
SRC_URI[sha256sum] = "8b72756d9e8e885c70de608923c146e6b293020de7707b48e6dbde72267ac2f0"
