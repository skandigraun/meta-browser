# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5be618739fc02c16a23775aef73488d5"
SRC_URI[sha256sum] = "65b41fc17bbcb6b8cc2e77f0a4585a9d8e3cb086bee182bac4218c02060fd84a"
