# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e0d99f89be52826513cb27603b928a9"
SRC_URI[sha256sum] = "7d60d70154f5c861dda1d621c6abc7179437244bd0fc9be1f6b2b5c270c011c2"
