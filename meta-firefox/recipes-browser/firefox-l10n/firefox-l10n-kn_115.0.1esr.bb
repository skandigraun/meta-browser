# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0933bb9524157ed98f220fdc7a40177"
SRC_URI[sha256sum] = "ae399a05f2541f1eee6a281b4936a0ba9c0c7792d5b5c6763a3496753eb53881"
