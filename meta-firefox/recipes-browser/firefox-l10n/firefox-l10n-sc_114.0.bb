# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14df725992e2ae1e11f2a52be31c8217"
SRC_URI[sha256sum] = "5616927e570383a915d35c76fab4fa79c606607c8f9d0cee597bc522e96216ad"
