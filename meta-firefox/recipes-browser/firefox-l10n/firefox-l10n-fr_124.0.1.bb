# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "023b4004a140a5a6d1724b70a0d5dda2"
SRC_URI[sha256sum] = "d17e31386be4dfdca4a4543b764259e91b0387f0e1a50d7d79348d18206aa6d0"
