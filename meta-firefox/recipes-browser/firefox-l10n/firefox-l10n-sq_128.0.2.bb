# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5bb706e69814c4646b853abb3137fde8"
SRC_URI[sha256sum] = "e74d083b03408d4c212352469af791b75ba037d50653d6943f808e9b04189609"
