# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d18458daeab7d0c225d17404318deb0b"
SRC_URI[sha256sum] = "ba0f9079997feb619fa9e39e8a35e6b87b082ccc39596d5d902570aea3928ec1"
