# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a525965e7e64db40cd06971581c94ff"
SRC_URI[sha256sum] = "fd5bbee5e8dba08c269af2358840f076142398f28c06d0cc4ac6e7de092dc5f1"
