# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46e32386a377d736ca24f984d333da4c"
SRC_URI[sha256sum] = "6cf4e04879e7892a84b7c15698be1c5bc98417e77c8323e6bf8c4869e54db7a7"
