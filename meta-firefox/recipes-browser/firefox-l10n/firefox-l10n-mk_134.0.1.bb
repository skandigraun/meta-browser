# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13a934f8ef1b8ab0f006fb16b0872065"
SRC_URI[sha256sum] = "d00cf3476049fc88c3ef04c47d37a3d60652e660875866fed85d0f85d4e86112"
