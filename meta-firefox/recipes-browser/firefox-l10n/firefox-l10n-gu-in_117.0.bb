# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9cebabd354f02ff2ddaff62d1e6c662a"
SRC_URI[sha256sum] = "58c316331339465eac0c1efcfa1a7e9b2044acbf1ffeda41e2716c3adb35e92c"
