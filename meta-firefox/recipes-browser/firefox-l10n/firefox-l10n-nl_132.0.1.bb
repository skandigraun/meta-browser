# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "322562fb12ef353a880db7fdaaeec77d"
SRC_URI[sha256sum] = "bd29dc37a3918a9a6d50635f0820f76f5f27c3113b6c07f56ef04e07c4a483fc"
