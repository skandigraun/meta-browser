# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e454ac94c6a2891b436f212a5f18478"
SRC_URI[sha256sum] = "8ea4d80232f7b5330bbb7dd10c3296b842ea8b3e6e10891f0eab29eb8af20fd7"
