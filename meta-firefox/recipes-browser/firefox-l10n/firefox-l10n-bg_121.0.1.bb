# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fdb1ffafcede0829f64a950b716344e"
SRC_URI[sha256sum] = "4ef4676b0105694aca607a83648626a8b4c3436e795287370ed06e5b875bc051"
