# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fc8ec03329148f853040b69d15b02c4"
SRC_URI[sha256sum] = "596bbc52b06db9752e2c6586bc5de7470a7a16bda0c4306e06d8b668d67945a2"
