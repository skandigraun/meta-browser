# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "426d09299e952f079681c74f5a58c689"
SRC_URI[sha256sum] = "f26318336cd7dbe7b82f66e718e34bea6b9ff80e0829dd518dc08b4281abda10"
