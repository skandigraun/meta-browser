# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aac59228953296401fc87312bffdde09"
SRC_URI[sha256sum] = "b7b305835d2da199f765a45122af0e00c7b74280c2fdf3dd1ca32be55d35a993"
