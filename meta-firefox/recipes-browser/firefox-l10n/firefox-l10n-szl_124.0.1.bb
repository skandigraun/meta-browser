# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec504b0f9f74519b8321505058d07201"
SRC_URI[sha256sum] = "4214c5446c8a6e14104862231b013e21c5d34abcf6e86709330a695d7c9f042c"
