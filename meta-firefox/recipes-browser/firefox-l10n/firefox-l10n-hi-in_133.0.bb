# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1e8cf71036281340c78ccad810f40c3"
SRC_URI[sha256sum] = "9ba1b6a3bb977aba8898e400edb225f6510e611649906ccddd2263be54d6fae1"
