# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fcbe5a175af0e14d9efc09a94a2fef7"
SRC_URI[sha256sum] = "ff691e94fd9b342fa140b8d9f41896284674dd734770937e7fb50000a1da7e09"
