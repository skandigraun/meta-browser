# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87d12f1e75b958d0234de383d45cfdf0"
SRC_URI[sha256sum] = "1b016b66537fa171af17c9d0b745769365e8ea77655d917368380bc2efdd11f2"
