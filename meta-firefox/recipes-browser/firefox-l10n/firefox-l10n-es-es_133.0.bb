# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3ad96bf9970d03e131c62e7cf6e33c9"
SRC_URI[sha256sum] = "4044d065a186afd2c8e0cba5a55e5b79fd65bee9b50ba5f5916ada014c08b47c"
