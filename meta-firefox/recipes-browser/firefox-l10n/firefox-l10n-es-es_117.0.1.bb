# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa81a467d963f92a6ca59b199a668bfc"
SRC_URI[sha256sum] = "1d9f41aaec637e5c74e6552d839fe7366e7ec5b6a20d598ff031f8327f6ba4be"
