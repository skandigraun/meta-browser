# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "830c3e60427217767a56710a506a5014"
SRC_URI[sha256sum] = "19330eb1e5bd807b9593930bf7af0fa7bd84a9fd76e64f313ec9d39f49476f3d"
