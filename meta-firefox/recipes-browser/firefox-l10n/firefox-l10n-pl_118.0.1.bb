# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddb93e11ccd52d6b69a9a945fb0803d4"
SRC_URI[sha256sum] = "f28f1f92676fa6a5d2693f50eedcf810dd8c2a1bb00a14a5975719a3874f57ee"
