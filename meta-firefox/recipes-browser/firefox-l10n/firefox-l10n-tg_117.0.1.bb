# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a0d41ca93ece78bb6dfc7e9d0a9b583"
SRC_URI[sha256sum] = "685f0893cb875bf3f2b281bf8b8671266f3e7cefd854ad0c74ef3391df49080d"
