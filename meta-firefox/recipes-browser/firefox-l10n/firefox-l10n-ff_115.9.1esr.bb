# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6b6df34dcac60ae6d271f9114ce5f67"
SRC_URI[sha256sum] = "1db432460a4d80a6ec35335016d66a9058f32373ccd3a2f3fa26d297e73b3c78"
