# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ab0108324cf5f486e857b8f9a3b09e4b"
SRC_URI[sha256sum] = "c329d34b3e802c8c159ed98569e5d6d440e7165520befd3be6118f4018373de4"
