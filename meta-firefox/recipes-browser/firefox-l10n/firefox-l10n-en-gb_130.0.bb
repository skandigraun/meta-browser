# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dadc87fed13d10243e9a60a89f1b5aca"
SRC_URI[sha256sum] = "951419f092574ba8218b806bf4053995f6368511a189555e083e57419bd4e5fc"
