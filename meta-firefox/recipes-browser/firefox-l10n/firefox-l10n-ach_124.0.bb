# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c0463adc53ad00a7c8b442379c27d05"
SRC_URI[sha256sum] = "cd39f210658217e6ca616af14f42348daffb826955f35d9f6b5ef9893df63563"
