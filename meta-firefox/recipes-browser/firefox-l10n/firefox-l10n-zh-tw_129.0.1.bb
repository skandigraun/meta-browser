# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9661b7f40cbb4b86ddaa898b7c79d3b"
SRC_URI[sha256sum] = "10ecd77c3abaa638ab9d2805cd8b21338da5285db244628ba5a27139298c6212"
