# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e4bba65b9b300d13188eee807166168"
SRC_URI[sha256sum] = "045ff5e6a99bacdeb1421061fb01a1fc71a76e12c9205cdd1fc58391cd89a613"
