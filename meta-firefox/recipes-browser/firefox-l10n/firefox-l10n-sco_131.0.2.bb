# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bef75d86b5292cb5b8f2fa6ae647e5e0"
SRC_URI[sha256sum] = "4c872569913af9de579d711b4d36101c64b2947e5ffd55fe13005b87263e876d"
