# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcbb7fbf76a5a15704df16aef17a73cb"
SRC_URI[sha256sum] = "3d3b51ea4b327aa3137ac0b9351fe535c7d9ba463d117518a13e731a22f902a9"
