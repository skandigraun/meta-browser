# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4b071cf197beb867c2f167801e96b2a"
SRC_URI[sha256sum] = "063f113044dc33aa19993d5811d279a48340ae20133d38ef11c15a08f0d6f0d1"
