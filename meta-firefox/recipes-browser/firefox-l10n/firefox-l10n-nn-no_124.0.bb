# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d4a586dde0925bff855eb192b80bf1d"
SRC_URI[sha256sum] = "f5ebaa3de83b75fd1959740af60000ecfd6135278c2c7357a2f01a06e94d3fe9"
