# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c68c19067531084c598fca369882340f"
SRC_URI[sha256sum] = "8a821de8e79a2b13717658518da6e5f31a6b0b82df581426006e99915a43bae0"
