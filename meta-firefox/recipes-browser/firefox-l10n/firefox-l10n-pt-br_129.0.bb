# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1915097333a7ac2afe5383ec0d7b4a4e"
SRC_URI[sha256sum] = "ec3fb17c030801e3e0e5d7135dcb5c9a62851b8b402de6d7e39946a79fa4e1fa"
