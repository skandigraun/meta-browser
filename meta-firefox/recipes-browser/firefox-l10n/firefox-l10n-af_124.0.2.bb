# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4a74cdf533561f54eee236a4acbe710"
SRC_URI[sha256sum] = "1180aee4ab08207f6ad5d8fc3442a8b22c69a87973ca246888c4805c9321ea94"
