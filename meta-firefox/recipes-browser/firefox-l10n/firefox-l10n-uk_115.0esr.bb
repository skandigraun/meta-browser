# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c658bfe0a759d520bcfb8de2b8e4ab06"
SRC_URI[sha256sum] = "599c5d507ef67e6d2dfb806992c63267f66b371d4401e4b4ac315efbe166f181"
