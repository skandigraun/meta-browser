# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbc05cd4b17a36ec8e11ca1f5454f499"
SRC_URI[sha256sum] = "76bf6d454398a237c15d509924151c81fc5ec09850abec8d412af1089459718d"
