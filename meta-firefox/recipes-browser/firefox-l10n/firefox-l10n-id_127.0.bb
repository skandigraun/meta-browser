# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "351ba0bd25aa76d656b164a196f63cf4"
SRC_URI[sha256sum] = "c2016f37adf28b57701ad3c18abe99f38efc7c8e4e2e18ac151773444e9ff74c"
