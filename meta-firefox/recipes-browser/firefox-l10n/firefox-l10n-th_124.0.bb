# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a68410d2b1f5cdcc34447a36fb055ad9"
SRC_URI[sha256sum] = "ffcddaf96893f41c639543ab23a180dd64234d0c54e1f98038dfe68bd5c67c81"
