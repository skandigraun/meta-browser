# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "39ff35183e243f7347c39412581d86cb"
SRC_URI[sha256sum] = "6aab71878426d1f9133530d6c16fd869598ff0f9782cd30d02e96bf5b3123770"
