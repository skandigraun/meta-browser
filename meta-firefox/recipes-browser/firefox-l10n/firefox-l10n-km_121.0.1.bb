# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9596d8fe0c06ad6d4abadb6c35178f8a"
SRC_URI[sha256sum] = "8d366fa707ba5cea6b7019b64d308fbd62fc795b6a43c0c929d71b55d924b570"
