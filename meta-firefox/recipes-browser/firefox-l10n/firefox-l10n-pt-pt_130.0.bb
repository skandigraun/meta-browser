# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2fa05bfe87502e64f2768bb56fd7470"
SRC_URI[sha256sum] = "b4032e8cb6ee6d931d00d5831a330c8ff8e5fe2ccc82425264c8ecea79ec0c05"
