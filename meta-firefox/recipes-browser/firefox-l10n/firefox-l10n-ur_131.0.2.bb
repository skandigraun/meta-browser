# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4befd4099342721d2c75935c92dcb376"
SRC_URI[sha256sum] = "df7de23b5c911a3863d25ad5353c1134465e4f0e6322346d223becae239f4d25"
