# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e5b1ab004900f4fb32178c425186a83"
SRC_URI[sha256sum] = "252f82fef807aba2f0fc250f12bec33e486e8daadf6069cd72e0bb5c3e09df34"
