# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce8bf8bcc52d0010d794e6a83677a247"
SRC_URI[sha256sum] = "bb1b6f5b6d46047519deb1d5e8157bc9c2aed59e66df374a6d9b67ce7cf59928"
