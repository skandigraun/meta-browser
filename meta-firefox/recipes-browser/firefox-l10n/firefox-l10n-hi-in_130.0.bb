# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a605c710be648913c588bb6ee761be2"
SRC_URI[sha256sum] = "950ac0031ab6de1c6cfe65491b58b7e89df31433a3f3eaff277115604d187e72"
