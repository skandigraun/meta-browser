# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "970a0880c6d00cabdc32b9411499ba87"
SRC_URI[sha256sum] = "c425c97c8ce51c46e4f92ed54b1852174fa0a006271571d1bddf018ac72e5ff5"
