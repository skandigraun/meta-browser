# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0505d51e9851634802a02fe755cc7cd3"
SRC_URI[sha256sum] = "97f4ec1f303122daa3413c8403bf930ef374cb08aa29e840830b17171de64350"
