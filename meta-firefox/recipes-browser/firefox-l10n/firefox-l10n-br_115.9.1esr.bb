# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23fb207abb3602a54f6a596fdc82658c"
SRC_URI[sha256sum] = "deeb0cb30c5ec312e801ca8a08c1ab2930dbcea39915af090dcad1af714d2802"
