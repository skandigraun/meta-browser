# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "794c017aa9b8139f160b27c170b7bb49"
SRC_URI[sha256sum] = "b8e971a1d5a9933b90cd89994a033631116799941d59604f5836c10f69c9a585"
