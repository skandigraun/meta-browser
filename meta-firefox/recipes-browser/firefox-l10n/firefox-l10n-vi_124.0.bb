# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d8b810e6428371c388bf5915e7d09b6"
SRC_URI[sha256sum] = "03e19b336f917fcf471159108d56fbbf075abf76232e23c6130c18681be9fdcc"
