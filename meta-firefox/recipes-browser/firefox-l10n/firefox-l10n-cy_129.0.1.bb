# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a0f50dfe403fd86576bc1dbc11b6087"
SRC_URI[sha256sum] = "62c56d3a23afa0644a5c943d44f9c9228bd8f947e79102a05ed98c2b9a91148b"
