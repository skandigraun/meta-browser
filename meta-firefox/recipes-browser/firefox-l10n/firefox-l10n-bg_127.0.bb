# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0801742035789989330b0d995182d5d"
SRC_URI[sha256sum] = "abfd2f5ca877f32c89f54941268ae0f3d80e5672e8b4dedb9113390b69fab790"
