# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5a9004915b7e1a319459efd9b1ca8f3"
SRC_URI[sha256sum] = "ad5af9e941d6a3bdb4d3c94d99b7e4533e800cf93397d82e519829b441c021de"
