# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e58b58f08749f189d0446887d5f64779"
SRC_URI[sha256sum] = "b6970526a27e7149048ff6ca977f8994889625b594f88a8fdb442d81089889e6"
