# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "472acab763a74a62bf4010311bf74266"
SRC_URI[sha256sum] = "ab9150e9ffed6bf78b6d51507b921313ff1c56955bfd394c692ec87bb5bd7464"
