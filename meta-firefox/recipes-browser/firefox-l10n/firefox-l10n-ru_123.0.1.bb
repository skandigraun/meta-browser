# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ef0e9152c48a00f9a4610f0e85f6076"
SRC_URI[sha256sum] = "97006888ffc497dfaf4b87296224440a5dc1974f14ca03815e999486ca230aad"
