# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c59e89a52d9ef5ccea886e333d5d9235"
SRC_URI[sha256sum] = "6bdcf536e00947f63341d193aad755f668ed17276ddc4854b287fccf9c447858"
