# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40dce7737e04d22eb5d32c1c2c52a77a"
SRC_URI[sha256sum] = "79aad20fdaf302c1b89460bd0f634c7beca4d12cfdb35369b2abf179288ee081"
