# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07186ae0f344a5a85236e57f13668332"
SRC_URI[sha256sum] = "e9429a9cffc570ec74e0fe8fd5cfaf25d14ac7a7af8a99baea6802c0f1c25778"
