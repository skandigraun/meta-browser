# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "190de8fc1f9675e0ba60fbde233f7271"
SRC_URI[sha256sum] = "c7435992cefb23155c888bc7ce34d1efbee511e484f0e38e18771bc99e17d391"
