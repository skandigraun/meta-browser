# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0243408cf93b30df9c4bc17aa18d2f84"
SRC_URI[sha256sum] = "8602191c207df14a8b6c3657c916fc27b249198e544a10b05e0f353226920ed6"
