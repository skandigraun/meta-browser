# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "648d73f92c5b71945ac1f5822cf0d0c4"
SRC_URI[sha256sum] = "61edf8f99f081efa300fa7eb94152cbb2fbefff37236ffedd76296045930418f"
