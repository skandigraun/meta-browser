# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "356d441f47137fb09d4e6b18dc4998d7"
SRC_URI[sha256sum] = "afb6acaf2253a842470102111249d33777c51b57c9d5d0bc4969beb11894b9f8"
