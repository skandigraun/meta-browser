# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f59fa61bd50e92a77e4bf97564d31e1"
SRC_URI[sha256sum] = "92716c232c90359f464670412361aacee2aca57c14fc408168719497c965374b"
