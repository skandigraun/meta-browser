# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3416923e285d5d99edbba4a9be38c25"
SRC_URI[sha256sum] = "a630d74f0bc79258e3ef9ec62643db8d755afafbcb89a3d128fc508576cda009"
