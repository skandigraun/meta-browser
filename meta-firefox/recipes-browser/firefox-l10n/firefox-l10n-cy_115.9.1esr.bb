# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb9055ade4ffb90d0d864b3843c3425b"
SRC_URI[sha256sum] = "93adaedbe91c89001d3208be2d3d912f82334c69be21c184f173a34baa349397"
