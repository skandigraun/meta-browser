# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93fe4e1703289aeba4fd653bf948d6ac"
SRC_URI[sha256sum] = "7032573a75d17fe67fd6e64acdc187f011160d9c6c9ded031ece37b76f9be32c"
