# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c5bd4fd1fab834de8317c88664f49f"
SRC_URI[sha256sum] = "36e4259a793caa8e236bfcc27e9f8f677ef54da9c9bf8e922bc26752635200e9"
