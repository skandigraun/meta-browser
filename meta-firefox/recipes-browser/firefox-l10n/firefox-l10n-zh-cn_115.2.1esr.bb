# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "460a097f134f25eb72030b67aa50ec9c"
SRC_URI[sha256sum] = "2e211db8c28dfcc4814b902417e20212c7745933a530f0ea4c6f8c4a372a3cd5"
