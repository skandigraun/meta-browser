# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2074baaacd98da1ac12255e92cdb11c7"
SRC_URI[sha256sum] = "346df20bf556a469846a6a23a9c8ed91ae1e5c4b19fd0e1dcfc5f320b82d468a"
