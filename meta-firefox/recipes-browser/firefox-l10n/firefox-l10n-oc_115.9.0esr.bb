# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15fd450ea3e040e6322ea980018ba1ca"
SRC_URI[sha256sum] = "34c3dd69455f9ebcb667695806f94cf80fdbd75c8e435d9c142bbd7919bd84f1"
