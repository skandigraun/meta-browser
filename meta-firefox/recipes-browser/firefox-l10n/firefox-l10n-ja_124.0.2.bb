# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cc0fc0429719d5ed2880b150e95b7c7"
SRC_URI[sha256sum] = "83c83c12729a47e55e93c12f55be553cd8d7b2239afd836a5bca8e91c21bf7a8"
