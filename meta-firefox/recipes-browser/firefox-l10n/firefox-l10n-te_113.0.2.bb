# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25dcf6a47b5c2d6f70ab6b773083aabf"
SRC_URI[sha256sum] = "98a832ecd5173fda4fc70d08ebbda0b004da66322b051031cf4e9f454e6897c7"
