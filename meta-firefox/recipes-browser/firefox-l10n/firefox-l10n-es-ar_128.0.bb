# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb9b0f644bfb60285b3eaa70dd08a3d0"
SRC_URI[sha256sum] = "eccc8c6aaf657d075f673ed540f0f7c1e3d793a397b48f072abdaa9dbba8311a"
