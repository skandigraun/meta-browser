# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f41b91a50c3c3d6a3e6423f24d4fe701"
SRC_URI[sha256sum] = "48eeb7e4899d42b54cbe307bd17bb2ed7d3b6200f015c355f94e037720883f29"
