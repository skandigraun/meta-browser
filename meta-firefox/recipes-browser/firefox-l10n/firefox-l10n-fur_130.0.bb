# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aee26ecb95030f5a62cabd79c920545f"
SRC_URI[sha256sum] = "96dfe34a3517d31587996ea2bb2b40aef1a986e52542cd93767eefc56eff0a68"
