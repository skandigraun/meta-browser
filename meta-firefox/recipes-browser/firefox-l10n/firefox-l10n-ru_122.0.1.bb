# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fad70903fdadccc44d3e277ca13c1fe4"
SRC_URI[sha256sum] = "8e8cf80ff1fa4693f33ff9971396ae4e787b75fa572ccade826ce46d168f9149"
