# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b78c34b08e9586a4b699fc73c4fb0511"
SRC_URI[sha256sum] = "054e1e071bcfd5dda125875e921b93ea4438c8a4cefa4be711d644d1a6cfe4e6"
