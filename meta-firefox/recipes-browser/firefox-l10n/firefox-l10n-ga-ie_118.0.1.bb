# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfc430c3d6a83bafab7c70a8565f7a70"
SRC_URI[sha256sum] = "dddb83be5ecad538ddab062ac759cd57d6f54d84aae77523251d0bd37b8c5603"
