# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bb9d7cdf8f230ddf380db4b990a7678"
SRC_URI[sha256sum] = "03aeed6498c98d52dc19910a8256f1cdebabe9a8f26f33f47520501c785d1e8b"
