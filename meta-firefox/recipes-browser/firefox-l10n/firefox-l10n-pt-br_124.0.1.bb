# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "621483a96a76365309e2152ab10ed17b"
SRC_URI[sha256sum] = "f2e21daf4a6288918a60ea0d2f1c3e942226d96f803508b221d90e533f601a64"
