# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32f29931b3e2500dbd6b9180548d126e"
SRC_URI[sha256sum] = "2013f7eef5cc4b1db6f445415527691b3b549203bfb695bcd6df06df252eaaff"
