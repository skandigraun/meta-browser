# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c9eb785d0bda5df0300b7a7037704c9"
SRC_URI[sha256sum] = "ff81b67d5355e30e110d051544ad294102efae7dba5b9ac87949fdbda04b9d88"
