# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "457a19f830d43d0974356bbb5dc91e12"
SRC_URI[sha256sum] = "7c7fdc2301684d9add77db15b223cfca6f80a5e54620ecaf377ae322e7568450"
