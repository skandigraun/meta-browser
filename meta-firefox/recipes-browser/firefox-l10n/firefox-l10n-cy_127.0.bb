# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e7d16ad1469a1bb97c135584a90050"
SRC_URI[sha256sum] = "1ce2a4ea221215ebc98953d390f4d7bbcf594848973df70cbaa6ab0b587c8891"
