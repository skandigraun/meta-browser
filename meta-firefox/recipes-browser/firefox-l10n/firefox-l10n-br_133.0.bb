# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8798427708af1ddd569dab770375170e"
SRC_URI[sha256sum] = "7abef21e93936127fa4a45e9a6db96e54f6bb63e79392a0a63d64546cd2ada3a"
