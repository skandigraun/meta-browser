# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a2e9958d185d95e11a392b845e29b8b"
SRC_URI[sha256sum] = "0d2b3dc98ec5597661583e035df914daa4f0b31bf4995d2b45e0834e3675b644"
