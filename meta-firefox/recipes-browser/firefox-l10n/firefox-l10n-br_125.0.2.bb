# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c9d1c5eeeac78c8cb27f34d5e08dab5"
SRC_URI[sha256sum] = "e0f7fec5c279210575be5c16a6a4649f453ed513211129f68dd65538e7f0e5c5"
