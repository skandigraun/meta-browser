# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70e1c9fb5d7995670c245fa89f8a22eb"
SRC_URI[sha256sum] = "1adc424db366daa0b87d0486ae43478ee70cec35938fd4f9fac3e1ebfeae000c"
