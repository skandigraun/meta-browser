# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d9f33742328ad3403ad628242a970e4"
SRC_URI[sha256sum] = "2c961870e1acd7f547e5d8d8dff2cb452ea8c2e25e931fec0d438775a2d3d64f"
