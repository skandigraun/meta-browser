# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "219dcb1d7ad91837f3e9c3f8cdf33dc5"
SRC_URI[sha256sum] = "6fa8ef0f21fc4526512e3ec1245d58374f6f2ad3efef9a470e6ff30b566aa77e"
