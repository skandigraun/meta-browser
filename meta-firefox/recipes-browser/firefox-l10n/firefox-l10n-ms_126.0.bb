# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50350a81e12dc5b4ca0e13071b313881"
SRC_URI[sha256sum] = "7539ac642c600862271755d8d94b95bd0b0aa41fbc7dda5899f4327061ecf860"
