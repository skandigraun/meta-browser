# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7d8607c69d5b7b786ca81c9ef0356e0"
SRC_URI[sha256sum] = "9980a00c71c9f60cfcd71fcdf0f32f0cf075814c175f51149cbc6e68c1584eb4"
