# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d0338bdf2c39fdc6ba75f17a6bb24af"
SRC_URI[sha256sum] = "b0b5e7b97dee6ae4abc3ef1a09b136bd783053edf84b822b959e7e30312641dd"
