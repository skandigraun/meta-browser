# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3505042b847606c620ff517ed4ed4d7"
SRC_URI[sha256sum] = "cb6d8a274eec88a2bbc9b5a01e96457a4554b111cb7eec077a78716ea5b32f7b"
