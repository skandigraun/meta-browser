# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb43d82895e11a26143424444231f1f2"
SRC_URI[sha256sum] = "ebec89dd46a0c582f5a9bfed1d4692a41024eebb5d9597b0142b00a54d0008cc"
