# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd9ed1ba43f9846bfe7fbd9c60e6ffac"
SRC_URI[sha256sum] = "b72afdf004e717cd00e6e027bc0ba00923148cddbec7c885466a807743236579"
