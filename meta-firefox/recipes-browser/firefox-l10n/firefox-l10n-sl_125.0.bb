# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320400b039d1ecfaf51e38943d0fbfad"
SRC_URI[sha256sum] = "b96d274bbdc7ebf89d5cb19040e9f0c6b57261175d7ffc7bd59b25717f1593c0"
