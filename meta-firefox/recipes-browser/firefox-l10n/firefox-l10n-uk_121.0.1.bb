# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b12069efde1f9bac38648b890c834cac"
SRC_URI[sha256sum] = "263d02faf51015e540cdf4d7b088982570dd8ba60311bb1227d5752de042b907"
