# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73347762865f1b93695d0014145d7f8a"
SRC_URI[sha256sum] = "b291e815484631bcae422c4d885a6f38cc4fd2cd30a42be1903feef385d2b36e"
