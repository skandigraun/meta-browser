# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c25d20993946ccb8221dc4b748f7f331"
SRC_URI[sha256sum] = "6664f51e3bed3f1fc7f3f558ff4213d46b8c0e16af4eb534573cabe984f3df31"
