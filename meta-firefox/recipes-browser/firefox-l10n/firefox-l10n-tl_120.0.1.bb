# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "041d0dcd0aee5497ab20221b175a49b8"
SRC_URI[sha256sum] = "8beb4748688b0e81deb96998582c74b4c8acb09145266eb35299dc0abfb02cfa"
