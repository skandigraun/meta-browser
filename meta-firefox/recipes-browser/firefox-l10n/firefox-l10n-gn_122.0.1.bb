# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91fed8a55b9a5c1e1c3270e777136b5e"
SRC_URI[sha256sum] = "cef4625bf78e7710afe6e2415c0c6898aac7eebd0d51dac69864de6c3ab32add"
