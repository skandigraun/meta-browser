# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "041ea0f68df94a07a3eafe2b30676b53"
SRC_URI[sha256sum] = "cc36579b82f67ae3d3914ff7fdc999b6faae7f9aeea23cbdeb3eca7e20e76dfe"
