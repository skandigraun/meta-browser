# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4426fee7fcf715121300e8a56ba66ec4"
SRC_URI[sha256sum] = "81161e7877fcbb56faecb854277547971ad400f91f6cad91b04d04c74a945044"
