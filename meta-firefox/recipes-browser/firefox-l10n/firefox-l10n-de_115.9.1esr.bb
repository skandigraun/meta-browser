# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3445f128ae680c89a4bb3e51d3de197"
SRC_URI[sha256sum] = "0e5091cdacc7e73baa3e7988f415575d3cf1ef08244414e311e5e90b436a5939"
