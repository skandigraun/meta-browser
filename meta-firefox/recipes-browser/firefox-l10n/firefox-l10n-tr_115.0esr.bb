# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a94bb68874a944b28dba0fb2804d8eda"
SRC_URI[sha256sum] = "91f722a609724e27267941b9b0b3e4e347886df830809a2a7c686da49065dc30"
