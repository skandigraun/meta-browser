# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9fd01a7338ea56053cbd99fc4d72c1b"
SRC_URI[sha256sum] = "104120e869de57478015742109b4982542129ef17b42e3f729a031e926225c87"
