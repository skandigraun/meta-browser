# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9995e11ba459120bcd9ff0438ff945a7"
SRC_URI[sha256sum] = "bb115e24b4783cf245fbd54a3253d638aa97f94309b637e5d0392836450df101"
