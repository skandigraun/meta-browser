# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65c5cd7599f199844d3d255841f6fa45"
SRC_URI[sha256sum] = "b73300ff91b4f6ed52c65d326490c7ff43f5103ed00db3ff6935eb3cbc35650c"
