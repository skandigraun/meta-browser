# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05c7a60601d9a3b7a377133376d1c37f"
SRC_URI[sha256sum] = "d231bd4b84c12b1d84f55cf6bc968efcaa7022c347eff35f2e329f0c26665135"
