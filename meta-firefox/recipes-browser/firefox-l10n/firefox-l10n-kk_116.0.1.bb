# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e25472d2a7e0033d654e04d71468edc"
SRC_URI[sha256sum] = "b9e27ee86ebac2f02b23d51130646bc97ae8d7031a8a208e8297b6c9f903d711"
