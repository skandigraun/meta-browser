# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "488bfa0129b5e93f09c5b0380429cc13"
SRC_URI[sha256sum] = "e0f7cff1bd96921b9faef2516bc50d4f0202be90daf8ab319cd6599d0d1e0d8b"
