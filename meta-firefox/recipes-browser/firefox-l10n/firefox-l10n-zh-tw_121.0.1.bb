# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f74978c69a961141855824a7cf498142"
SRC_URI[sha256sum] = "d36fcc5dd169f10fde5283963819956cc25a12eebc51d84704b088e3dafc981f"
