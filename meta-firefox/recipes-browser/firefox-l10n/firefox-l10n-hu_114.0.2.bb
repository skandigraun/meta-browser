# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a74c3523a754cfb43cdd9ffe583fcac"
SRC_URI[sha256sum] = "5058dfd3f59a36fafea4e69143487566037365f599342e88356606d568efa14c"
