# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e93b396ffa748b69d770410f3e4f378"
SRC_URI[sha256sum] = "265fe02a718a66e00c2f0c107b1c7178ec9d6ec81dd6164a53cc7753600d1639"
