# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef449f58cc5c632f6baccc83da871cba"
SRC_URI[sha256sum] = "e13371a28f5be57ad4ed29cc8f7bfe5807f4744a5d0296c14f82871c26e99f9d"
