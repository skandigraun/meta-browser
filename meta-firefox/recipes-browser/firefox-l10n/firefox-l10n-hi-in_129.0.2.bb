# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46d4d4621b2b9e443ac7924990f7df7c"
SRC_URI[sha256sum] = "c38b2578bd5a7e29218c87e1c61ef1411118a151aa945bdc63c0ab4a719a574a"
