# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ada978501fd005ab3c4dd29a44a2389"
SRC_URI[sha256sum] = "654c1c16a853a3c1c46fb4b0283f73fdd928034b6b0984a2b76cb27fb27abc09"
