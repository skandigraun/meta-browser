# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44251be1578efa64d35d73729a90cc7c"
SRC_URI[sha256sum] = "6ee160e27941fda36e092b68b1c55f2d558965a8cf4411c02707f169e4a76194"
