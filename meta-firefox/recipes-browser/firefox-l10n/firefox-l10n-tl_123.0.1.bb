# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "254616f713c7d8c04989d5f1a0d06f2b"
SRC_URI[sha256sum] = "7770b38df11b4a157a14207e2f7875fd164164f9bb0f0b552cb9970fdcc65f8e"
