# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a8d4f2d314398439be4ef3084e93857"
SRC_URI[sha256sum] = "7e67250051bdccd9b6eaa028ff1d7703a1f77eb95397b04229694e39b9465584"
