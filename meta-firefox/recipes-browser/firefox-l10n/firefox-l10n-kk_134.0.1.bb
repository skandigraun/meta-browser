# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c730bb1dfe907254659645002728bb8b"
SRC_URI[sha256sum] = "0158504e8613bc723f14c39fc2b02d607dd59d6689cae183e03353b242527440"
