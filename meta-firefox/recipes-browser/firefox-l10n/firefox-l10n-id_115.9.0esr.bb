# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7d29342e276b228a62fe4738df7e149"
SRC_URI[sha256sum] = "1a4a50ba3c03fe54c359a38011ae45f80cc3353631292d838a0e3ce35cddbde0"
