# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "546e038a8331db8efafb7e20a6670e5b"
SRC_URI[sha256sum] = "79cba2a6a4bc1355d95f58d798522d089885842a72c171d3b85c99d348828f47"
