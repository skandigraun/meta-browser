# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31e6249c78d1a16ab53abd24cd3a0ccb"
SRC_URI[sha256sum] = "dfc7e3e9d54d49a0f5518e482083e0e6fb73c2fcb7e70ab5f3f7d8a9d77efdfd"
