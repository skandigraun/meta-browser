# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4856a8455f6ab63eeddd59720420b4a"
SRC_URI[sha256sum] = "8e0c41dfc01d0f2eda862a5394029025dc3cd9dde99ce7b53989d2ad5659939b"
