# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a7346006eeeae8ed7dc60c948396531"
SRC_URI[sha256sum] = "c7503eeb61bdee6246a712df253cc5c2e414144ecc2bd326b454dbb7e28c02d2"
