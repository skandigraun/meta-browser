# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "778763291b80c7e28c4bec45c80ad898"
SRC_URI[sha256sum] = "72b05a25f34e9db4f8a65eb630f3d4a5bd06973599d2bcf65152e9d8b89dff0a"
