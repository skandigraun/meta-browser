# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4712674086341d741fe7c36c51a7cf54"
SRC_URI[sha256sum] = "e3de7820a009da24cc333a4734bfe2fdd846323ae635679ac57bb9ab4480d255"
