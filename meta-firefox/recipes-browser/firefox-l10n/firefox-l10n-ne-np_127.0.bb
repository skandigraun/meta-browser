# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "459c7abe8e2230690001da7d80b2f84d"
SRC_URI[sha256sum] = "8fdd69996234fc42c572654a4aa5a369d811e6deb917aa64ea3672200f859751"
