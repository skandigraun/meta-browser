# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34c714bac2a12a305e7ae35f077d1442"
SRC_URI[sha256sum] = "eac6df4d4759d6126fa8663bf8896f5a8ddc10e94ba3ac92f5aa7335a10bda18"
