# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b170a5cebd29f3a946ccbf909bebc1a"
SRC_URI[sha256sum] = "12ec633c84011216239334c2f08eaa7ec4e4fa4f9c4d9277d6275a84f6df467f"
