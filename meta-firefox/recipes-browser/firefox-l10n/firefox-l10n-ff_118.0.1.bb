# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e262bea8eada66bf34b191fbfe5a683"
SRC_URI[sha256sum] = "90bb4a0ae8a756742b7a7355f387119bc86c639536688657e847f404009f2335"
