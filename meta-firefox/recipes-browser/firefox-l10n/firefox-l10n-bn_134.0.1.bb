# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81aca4d18c70334b6f4bffa552ac865e"
SRC_URI[sha256sum] = "260a78a422a8fc40e2ded25a5f6aeb694be184e8d683f40ef97fedb144366841"
