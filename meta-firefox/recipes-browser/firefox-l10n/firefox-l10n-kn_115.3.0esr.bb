# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4016cbb34e04bc4231e593fe6945b422"
SRC_URI[sha256sum] = "03c023ffbd5e70655de29215a0f427db5239f203ab9663412bb51460d0bbb1e1"
