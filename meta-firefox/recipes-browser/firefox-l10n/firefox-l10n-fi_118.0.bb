# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "773228dcf9a8dc2082939c82389d13cb"
SRC_URI[sha256sum] = "3a848a99e7a759671f62ec3b64b3daba46d7dd1c7354753bb49b47bf0e7caceb"
