# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c920282f89346f275bac263809933d67"
SRC_URI[sha256sum] = "b80aaa1569b534f89cbde44e2772e33028f1ff0f323cc01854f68e13ab4e2f97"
