# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c700ea88264833a0fd172d80e4234bb"
SRC_URI[sha256sum] = "8bdb9c8f3b783a03b3a4b8160c5661a54261aabef5564b98847c0138d83ab2cf"
