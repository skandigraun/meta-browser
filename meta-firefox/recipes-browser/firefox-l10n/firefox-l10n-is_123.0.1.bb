# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a2fc89c9b22a51fc8ca4cf99ca80d98"
SRC_URI[sha256sum] = "d930ce591f4d81eb34d916001175f5a67102a7fd8e2b302e5ab4921741bcb29a"
