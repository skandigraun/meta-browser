# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6560b34e422dc1c2b0e799e06a9be67e"
SRC_URI[sha256sum] = "9f25818608d952c5cd87463554d0d1aeb3b85494978361b058e90ca515e19f80"
