# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43df585fcc1aa24fee72c1044513c421"
SRC_URI[sha256sum] = "10f86fb589cecd833bc144de90193277e7c6f1ca6e9c64981fa1f94c77dfe352"
