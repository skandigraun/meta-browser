# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ed9dd5f7d95126a4b88f2118c2c2b78"
SRC_URI[sha256sum] = "68d8dbdd1bda2ec7842cdb729a11e3f8666713d1e8b04c4d7a37269b495b8b8f"
