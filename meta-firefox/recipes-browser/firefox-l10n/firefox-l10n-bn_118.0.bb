# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75dc59c87d8363d588e0c92583b8b713"
SRC_URI[sha256sum] = "0890db0ae7971e4e540191730bcdc0288ee6dbfa6d8db338be298fd94ce1fe92"
