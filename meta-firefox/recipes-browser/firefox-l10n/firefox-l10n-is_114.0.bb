# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4a8a953d4f6d698066865e562edb006"
SRC_URI[sha256sum] = "49e78397cd9d8ec6ce22f6503f89132009ecf028719f5b5ddd1164922184ffa5"
