# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1bb362cc956c432928142f50c3736177"
SRC_URI[sha256sum] = "d426652fd0a084e68d4638adee0343ee84d5a99de7b088e2208813f7ab7e3ed9"
