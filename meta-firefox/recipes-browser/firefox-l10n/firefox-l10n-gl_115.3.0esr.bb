# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7755898adfdabd5b2aaab36f9b0e84e3"
SRC_URI[sha256sum] = "6aed46f4e8ff23cb53d66790fff53a4d10565870fe44892ec98fd0af86f8c472"
