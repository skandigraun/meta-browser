# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1a899d19c99b475a6bfb8bfc1385183"
SRC_URI[sha256sum] = "79aa677e88dee9eefc0a3677dedb3b88277cb1dd6c2236a7eb8d7245dc32e7b0"
