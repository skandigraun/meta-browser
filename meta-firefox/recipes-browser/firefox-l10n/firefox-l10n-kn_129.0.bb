# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2ffbe57dea7792b3d381886bf18ede2"
SRC_URI[sha256sum] = "111eee49181c7caec858cba0b7ea7201df750e9362d249871da330a6ba2b4cdf"
