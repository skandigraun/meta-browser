# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60a304dd9c0cf294b8bd5a605d992f77"
SRC_URI[sha256sum] = "a23be400c3dd83e6ff2aa4ab551fbefb770205c0cf75305576260cecfba8aa2c"
