# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc38e9e4cbad8f38520036801bfdf404"
SRC_URI[sha256sum] = "2c71c203ad2910978fbb724e7e226eb1ee9ed51fa0afae7a802866368656c002"
