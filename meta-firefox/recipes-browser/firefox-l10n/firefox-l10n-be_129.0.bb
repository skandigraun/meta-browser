# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8eb4019959ba105b8d788f24a58939ac"
SRC_URI[sha256sum] = "d2ce91b3fd864c64badb1338c5033c0a4859f9fc3a85e5e0d3ca0b4f762bf95b"
