# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "193e382245639cbdb9426d93aa23a5e3"
SRC_URI[sha256sum] = "40f96d4f214a72f8a2f221e88c1f90aafc2a55c6f7cb95cdfc6622128a5b42af"
