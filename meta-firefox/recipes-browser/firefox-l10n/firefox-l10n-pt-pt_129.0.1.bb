# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bdd83cff6f04beb23fefa91206671b3"
SRC_URI[sha256sum] = "26d4b5e66a42d2be81e819f1322401524b74c670698bc3464c332ad499fe8d0a"
