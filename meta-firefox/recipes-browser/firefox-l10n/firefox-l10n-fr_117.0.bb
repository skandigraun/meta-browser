# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7276b057c14a7134d42d593e96b1bd40"
SRC_URI[sha256sum] = "6a3383cbc15a3575e038a245c085e44781b5dbbaeabf86536a336161efec1f05"
