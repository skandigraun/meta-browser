# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1595bb220028373169850c0adf9f7421"
SRC_URI[sha256sum] = "0a86db85903235c95f20172fee128523759b401ba7d19a45dc8782666d7192a6"
