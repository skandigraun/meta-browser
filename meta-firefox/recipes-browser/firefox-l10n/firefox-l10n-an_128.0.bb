# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8634c3c20f75610a9189373a0740a01"
SRC_URI[sha256sum] = "4c238548929552959271dcdcfa914104965861acabb40a6db708908ac3e21cb4"
