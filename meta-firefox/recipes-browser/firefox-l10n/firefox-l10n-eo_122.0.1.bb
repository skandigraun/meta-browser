# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8ee97ccfa997c9b88b0ec6ff236bef8"
SRC_URI[sha256sum] = "880f5cb6ddf5ed6bcf3e008d08786aaec5ac138c986f877ef21ee769030efc1c"
