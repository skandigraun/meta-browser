# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "274cf363c8fe7dee5dcd048be9aac293"
SRC_URI[sha256sum] = "cccd83b338af2ab8ead4074760a78554897ca3a6ebf96d4890657a25f6300970"
