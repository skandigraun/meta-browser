# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93b4c83136c61830303a2d808c268b68"
SRC_URI[sha256sum] = "1771b170114a823759df55278f32985703253c92a8f0ebdb0f3088d226a3c778"
