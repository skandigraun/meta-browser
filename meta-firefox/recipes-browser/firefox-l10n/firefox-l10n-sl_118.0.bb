# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6923046f9c4bec1587f5299d28ff7af8"
SRC_URI[sha256sum] = "f77db2e6c0ec499270a0bcc86bc205f0b2078f357d9ae6c1b539a9337903f027"
