# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69ddd5991f9a72f4f6c4e1c186ee8630"
SRC_URI[sha256sum] = "64eaff727ece2584561bf590038f95bf4bed3b42814c18cdc562aa41ab12da9c"
