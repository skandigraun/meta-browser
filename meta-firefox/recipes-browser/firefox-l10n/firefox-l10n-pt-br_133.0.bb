# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8822ebcbfb6bf5ade79b7fd83505d38"
SRC_URI[sha256sum] = "f02575d0a8cc71297ae8aa73685f405fb1425176c3b48a24b86dc149bf8b663a"
