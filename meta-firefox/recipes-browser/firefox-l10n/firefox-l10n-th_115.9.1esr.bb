# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80a8ea055d2b84a00ebf1516dc2b0e3f"
SRC_URI[sha256sum] = "f422e8c56994c9815f201b54dda2c6415dd115f4806d5caa3d6278dbdee8de60"
