# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "977eb30063eeafd6e2c36edc93f9f6b9"
SRC_URI[sha256sum] = "d4b333b4cedb9c9f2df8fb8978b40b2d0868c7c66653fbd40e76f6a98172f657"
