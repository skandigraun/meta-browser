# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "244651bf34e740a60c7fcd7c25f69643"
SRC_URI[sha256sum] = "7d3a5d330cbf8310f09bbffe573bf299c565ab78d328ccbacd24242546c6c1c1"
