# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "945adede521dde044f0d4cc18dad3461"
SRC_URI[sha256sum] = "0d61d56b9cb10e9fcf5e7564d5eeea55bb06fc6fe15cec0053bf9a41fc543a30"
