# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bcc8ff50c9ea1266e297147843473924"
SRC_URI[sha256sum] = "2ba25871b76f0b734bec2b9f5b6aa8fe146fdcda22b60194a3bc32206a6dd694"
