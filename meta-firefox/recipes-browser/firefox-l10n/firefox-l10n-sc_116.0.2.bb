# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f0ab943b495233020653efeca46627e"
SRC_URI[sha256sum] = "5670f6982baf5d4f6ca5beed219312e542269df53722b2d46571d5af4ed89328"
