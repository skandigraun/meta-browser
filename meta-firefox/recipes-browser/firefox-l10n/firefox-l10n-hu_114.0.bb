# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7e6707816c2557356721c7555fd396"
SRC_URI[sha256sum] = "b3cfcc9e008fd1800d6688d5180e9fbcbb0336e16e444f81715ffca4d1ddc96f"
