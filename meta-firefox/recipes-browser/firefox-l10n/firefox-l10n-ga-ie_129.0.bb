# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e9874ec2e568b0e9d0733221340d119"
SRC_URI[sha256sum] = "6f5c68f7159bb18e1044a4c4f54bf565114259f5903dcdc98f4c29f348ae7769"
