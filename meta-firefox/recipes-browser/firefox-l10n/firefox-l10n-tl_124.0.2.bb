# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73cacb7f4ef4a8c616d81d82249315dd"
SRC_URI[sha256sum] = "af7e664a3ad25339ffe8fa40bfd6a99876acec93917dc570ff1a1a501db904a0"
