# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e822764d2dc951ab137b6cbcabd909b6"
SRC_URI[sha256sum] = "7539c87e89e9b92a17950ab2ad843178659b1112cab4a491bb0704ae5d3181ac"
