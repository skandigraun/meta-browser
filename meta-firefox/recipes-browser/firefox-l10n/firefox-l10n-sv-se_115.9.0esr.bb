# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48154e68e0bab0906bbba1c2136a0d70"
SRC_URI[sha256sum] = "2d960c05c795bab26210c2af32470ef4500bba35ca2e44212421d0599b220d99"
