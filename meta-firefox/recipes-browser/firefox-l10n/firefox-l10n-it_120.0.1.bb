# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e6345ce86fc50529fbb3cb63a198a24"
SRC_URI[sha256sum] = "e0dc6191fd28017f2c582e0e02076aea12f5c688e4571a6e52a6f8da99387148"
