# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dff7272dec7c28c3a49356e091f1f1ba"
SRC_URI[sha256sum] = "cd56be8e36aab0f9bbe9f11c83cf4cec6c6f0f27d6b7add19f122d92ec4a49a6"
