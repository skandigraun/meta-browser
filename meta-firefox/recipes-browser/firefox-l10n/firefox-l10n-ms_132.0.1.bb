# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcb675826b4d5e72cb829f6d89ccef16"
SRC_URI[sha256sum] = "35543fd6a8a9538b162dd3763bedcd60faa964d5592d76ea738790b97c8e8911"
