# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8da1d0e7a9c43c7379445a89d6e85bc3"
SRC_URI[sha256sum] = "3ac48396786b48cf7487d83ef214053b864c5961a0fac4dd01ffbfb87924ae13"
