# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d466ed3690e3c268dc97be6f98483a0"
SRC_URI[sha256sum] = "8942ab576aa34d00c9c9a1b2d763e8ab91537e2dd816702c96bfe5783823f4e0"
