# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a468eb5be1a29d763645c10eaa3c7c43"
SRC_URI[sha256sum] = "45e05a2f778f9959c520eb5e5a3fd530bee6733c2d42e4175715fe8ea55d60ab"
