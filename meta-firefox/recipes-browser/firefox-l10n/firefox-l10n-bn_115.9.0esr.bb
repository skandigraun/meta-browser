# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e386eb246a85546ece82061aafef24b9"
SRC_URI[sha256sum] = "3879b9b83a1f80e1c2d85d9b5dd64909cc2aca55be7016a2b8217d273020d3ca"
