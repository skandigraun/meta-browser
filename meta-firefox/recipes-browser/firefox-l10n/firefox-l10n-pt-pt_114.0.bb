# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4e62a32bdae5904c13ae221aab6744d"
SRC_URI[sha256sum] = "62d73008f29ffc7078d1e2bddb36f360044f28a3bab820832b6ea82b07582048"
