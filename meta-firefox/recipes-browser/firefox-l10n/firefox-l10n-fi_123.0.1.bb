# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12e683f0eeb6dd23aa0ca99d3a5f99bc"
SRC_URI[sha256sum] = "bccff9eb3cc665103f3c2be0f85516a8a082be5bf0d87b08e73f9dd1c5933237"
