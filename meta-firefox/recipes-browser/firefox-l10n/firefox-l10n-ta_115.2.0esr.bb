# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10b560aa81e37d01184ba62e551cc2ef"
SRC_URI[sha256sum] = "04cd36e04a780989cb49e41d07c51f12ca9bada34b5d612644600ac8c3eea1ce"
