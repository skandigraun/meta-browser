# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a07aad8f5e0a4d42065f2c58fd66fad7"
SRC_URI[sha256sum] = "3ebb85c2974c9d69f4e9c816f338da304a58469034997f83f0cd9056c4acb6d3"
