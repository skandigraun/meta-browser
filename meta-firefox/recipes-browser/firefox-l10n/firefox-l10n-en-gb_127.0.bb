# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f0a0b16d8bf402357197ecaec95feb7"
SRC_URI[sha256sum] = "05ed56a97ad02fe0d57b93e72c3d99d5510a6cec3d490e67c385999d1f2b1c63"
