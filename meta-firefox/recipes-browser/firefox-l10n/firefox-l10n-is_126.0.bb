# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dacd291a85814ac3079c1cf879c52457"
SRC_URI[sha256sum] = "90450928c8fe9e1329a1ea6cc726c2eda0e00a3a468b11d2573fb1dda6d93356"
