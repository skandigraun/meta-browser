# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5282d1047a6f4cb847708929a68d982"
SRC_URI[sha256sum] = "5176150a2398d914b9d1df89afd13c1e5d3ca4f06b16107afa487f7ae99f2ebe"
