# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cba34da1640ed2d85782187edcbfdbb"
SRC_URI[sha256sum] = "dbd6a50b9e8495f8616425e5e5ab76de26df79cba0665bc6275a822434a8e1d7"
