# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f910d31060f54f411a69e0385754566"
SRC_URI[sha256sum] = "b7a0869cb1d724649ae7b7a99d2eda4d363479cd5a5c35425bc9fcd314bf3f99"
