# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f54f9aadd0aa7324bcf335b79fa1f81"
SRC_URI[sha256sum] = "c46c936be5af01c6f54e3bba1bf3f0d23521b10161ade899b085e762cdaab7ab"
