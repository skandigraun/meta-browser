# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6dda7252818ddc758abe502a710a47b8"
SRC_URI[sha256sum] = "8ac24bd9d41160ba2f0e5a5c7e5a8c8d25d4e827225a8dc7acd7ba2314b3fc20"
