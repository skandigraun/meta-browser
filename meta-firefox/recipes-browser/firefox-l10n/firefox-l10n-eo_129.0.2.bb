# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8322af5f51aab88e67bccf7d60a2f45"
SRC_URI[sha256sum] = "6a64255bd465f5f858223aa85fe67a43d30db6cc248b321530854caabbb54805"
