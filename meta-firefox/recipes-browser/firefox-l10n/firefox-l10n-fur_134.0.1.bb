# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cc0bb0cf639960f9cb2a25ab2f88b7a"
SRC_URI[sha256sum] = "7bf6ab924764aab79c77f982b3d7be03cf78230d3f260bef889e43088adfdcde"
