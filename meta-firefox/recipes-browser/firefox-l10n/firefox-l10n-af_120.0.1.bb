# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ec3ac873dccb607fea16c5d43921831"
SRC_URI[sha256sum] = "6ab0c0d3046f016b4eae9faa5b72c3747a5019aa6c6af9d4b18a5410382eb6f8"
