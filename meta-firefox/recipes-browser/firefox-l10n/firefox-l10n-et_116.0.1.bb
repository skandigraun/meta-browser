# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41f71f1e978dce6c173dbc0ef7c9aa02"
SRC_URI[sha256sum] = "57ff1e63dbffc7eadbfca752c67b0ffe476d8095d7c82f900bf6241f150e6681"
