# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f8bf68f86563bc4e5babc682788e211"
SRC_URI[sha256sum] = "e6df4046232b1e82eb8673e0332eecff464e74337ad304b0620f3c63a0f43ad3"
