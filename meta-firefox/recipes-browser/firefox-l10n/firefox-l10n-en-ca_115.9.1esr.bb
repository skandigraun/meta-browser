# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "568955398f4001b56f65c47111e42f55"
SRC_URI[sha256sum] = "7749f021abd08a18f78f6ab3d03f07c3f306970eee320a3256322a3e02cbf145"
