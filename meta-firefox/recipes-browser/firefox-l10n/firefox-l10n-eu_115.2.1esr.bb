# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "762e203d3565594a52a416ad4e1eb222"
SRC_URI[sha256sum] = "a0f069f237833961a781d79aca9fa94c873e6e7c1effc206f383d810e602309c"
