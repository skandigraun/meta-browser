# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b303911182a3727bfdee55993ba95fc"
SRC_URI[sha256sum] = "2801867ff45250c11266400b16e5c26047607dfdbc1381da5a735e280fb9017e"
