# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "805fcab2b7663e139242829404d7105e"
SRC_URI[sha256sum] = "496751a138d3a1ef20f726d45290757c0022c6c19ee0db6a19aa934b78c75dbc"
