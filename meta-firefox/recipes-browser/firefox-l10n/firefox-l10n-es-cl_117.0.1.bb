# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e2df06a304e7168dbd5fad8f6ddf287"
SRC_URI[sha256sum] = "2f9c429a8076791649f4bccf2d13c67129565d5a1bdc3717f3380462d61b4b76"
