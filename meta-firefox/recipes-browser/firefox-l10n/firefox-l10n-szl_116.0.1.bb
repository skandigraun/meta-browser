# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c63a1c0b1fbe757381776b2c8a6a93e3"
SRC_URI[sha256sum] = "8519036284e7262a1a2b98d953cba1f46dbe5dfd96d3ded76364190873451eae"
