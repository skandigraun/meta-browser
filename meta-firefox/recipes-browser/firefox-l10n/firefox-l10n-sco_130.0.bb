# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "858441479c3203dc805b5add33ebb27d"
SRC_URI[sha256sum] = "f7a0c68aa2fa7f3c574ebb52cdf1e69a76f51da5bed7b171cfbb769ca6797c59"
