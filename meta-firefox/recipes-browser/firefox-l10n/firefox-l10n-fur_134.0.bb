# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2f5c768256780a3dfcaf674ce87e87e"
SRC_URI[sha256sum] = "0503f9a46ca9792a1d1db77947fa5f4d8407b22fb8d954378427a86ac2324073"
