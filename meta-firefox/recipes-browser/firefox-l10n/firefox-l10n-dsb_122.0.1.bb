# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40eacded6e58b2e5e79344d4b588561c"
SRC_URI[sha256sum] = "e0b2e97a9ef92257ecaa4317ec132f39ff592faf3d98b863a5b53720740fe7f8"
