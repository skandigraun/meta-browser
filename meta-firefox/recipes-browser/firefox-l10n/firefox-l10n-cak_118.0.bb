# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb6ab812c8f755e91409a2ed6195ea34"
SRC_URI[sha256sum] = "957ce719d41e3176fb6580f4d2e188d2da1f0144896dd31e6d02eb65d77b45ee"
