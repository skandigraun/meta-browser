# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9073e1f5237888d2d36449ae7e4086f"
SRC_URI[sha256sum] = "53893456dab2a8d6e8d401e95b555f897d91a60e9b250ee8262ecebdc54b52cd"
