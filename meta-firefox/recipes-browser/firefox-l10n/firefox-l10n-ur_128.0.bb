# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a316752a46aaa70bcd8a8f89c0dc52bb"
SRC_URI[sha256sum] = "c0f307143fc76c38304c069d4c3991ae4e14fb548f29494f1b97c74c0ad9fa4d"
