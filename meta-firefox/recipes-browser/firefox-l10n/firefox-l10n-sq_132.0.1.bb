# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67bbfbe4d067ea2f2e24e698bdee862"
SRC_URI[sha256sum] = "f4402a3eb877c83ee81840e076a49d35c747624dc33c1b6e4119c86fe9bbeb82"
