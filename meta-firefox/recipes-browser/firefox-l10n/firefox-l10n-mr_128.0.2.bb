# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b40246b5be58c6b5c2a34933c26793b"
SRC_URI[sha256sum] = "1e835f426a952af1bab5dbd9ba610abc02e1c5c61be4d5065267e335797a591c"
