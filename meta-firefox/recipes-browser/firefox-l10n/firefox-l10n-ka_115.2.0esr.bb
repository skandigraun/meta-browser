# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58be92a9929861f5961fd1ed522ad409"
SRC_URI[sha256sum] = "53de670fbd2850062b35c21c8b2f11a056abab54120419c3274397f8ce63feae"
