# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "611eaa66a4d6f5f3774e045467320879"
SRC_URI[sha256sum] = "228d86d4ef8afc82a2a630495854adbf7ccf77efb3fcd7d50582e54ece286ff5"
