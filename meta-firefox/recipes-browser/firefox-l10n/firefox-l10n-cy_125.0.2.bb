# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d557f668ff62c209846e7de8b63b27bc"
SRC_URI[sha256sum] = "fd039d74ab2d1a2b5d34fd73819eea8ea8a41dc5d3eb3409fbc9aaaae1325358"
