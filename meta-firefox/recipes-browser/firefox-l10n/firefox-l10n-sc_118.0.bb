# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dc5e170fb88d14a9521124ccbbce2b2"
SRC_URI[sha256sum] = "543b339673e08f8cc20c347befacab732b8908671846a9ce9358921cb1999b1b"
