# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f10b9720772d79141c4c2216be4f8712"
SRC_URI[sha256sum] = "267f79bf0eef5915597b4fb3ddbd431243629263328238f350f1bc6ff34335c9"
