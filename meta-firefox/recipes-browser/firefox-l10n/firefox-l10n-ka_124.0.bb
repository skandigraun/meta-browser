# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2eb9d54af5ff07049800afb2ddf585d"
SRC_URI[sha256sum] = "75afe041ce762dfcd2d0f62a92f4c99a27ad260479875bff3d3d803edb71025d"
