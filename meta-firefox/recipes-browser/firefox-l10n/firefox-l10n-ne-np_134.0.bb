# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4e72cca6609ad4c4c4cea4c445e69b3"
SRC_URI[sha256sum] = "fd022b824775553264061ae66f005c10debfbcd0c7938d7317bb67d6ac90cf8f"
