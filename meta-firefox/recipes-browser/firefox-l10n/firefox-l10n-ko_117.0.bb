# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dfdd3babe965748f70fdd9980df84a13"
SRC_URI[sha256sum] = "a2d84f833ee88a2d438a63feb48933da6d21dc5f34bd5481f821fe25b1894d2f"
