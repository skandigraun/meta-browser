# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e7a3f9f79f5e3c0402723e0beaf61e8"
SRC_URI[sha256sum] = "3c2e7ce654957f78b28fed47f3c3eba8fcb09a83dc680aa4c938e2936a255d0f"
