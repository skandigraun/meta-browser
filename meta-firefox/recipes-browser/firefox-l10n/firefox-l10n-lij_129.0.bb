# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9364e4879a8b634b5f2c2bc5baa9892c"
SRC_URI[sha256sum] = "6d49cb29d0bafe2c4e447d66c359ffc5d330c47f3ef80812f1a61ea415749a2f"
