# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4bb800f6c1ad78247ffbcdf5f1d1e22"
SRC_URI[sha256sum] = "1b21a0e293df417c8c2038322826edde547de3dbce1c4ca6c4d6337e30d3bb4e"
