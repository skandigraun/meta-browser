# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "375309d5ebc1bbd7b2fde36aa21ee152"
SRC_URI[sha256sum] = "102846d56daf70a46bcd0998958a73e7d143dfa4c68e1f4efa82f43adfc40f45"
