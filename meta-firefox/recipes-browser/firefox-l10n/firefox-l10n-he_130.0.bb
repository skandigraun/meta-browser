# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f49cf6fc976b1c60de0b6014e23c9a31"
SRC_URI[sha256sum] = "d378e5bb32bab8081cbce991c8a60dbe8953590aa6848fbe6ea4d187cdf69a49"
