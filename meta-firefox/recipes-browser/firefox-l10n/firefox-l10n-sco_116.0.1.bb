# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "786488b5fb5790d3fef30f01dcd70e11"
SRC_URI[sha256sum] = "39bd63eb784356b9f263379e6714147b0c4c73a550061b3a0409cec2e9253b3d"
