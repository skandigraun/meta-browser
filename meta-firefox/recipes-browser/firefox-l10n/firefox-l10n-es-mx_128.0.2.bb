# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc7428b6e9396d6182c084f531c7c891"
SRC_URI[sha256sum] = "6f03b52179f83eacca1faf3ae35142254cd9605124a624fa8fba905f652b586f"
