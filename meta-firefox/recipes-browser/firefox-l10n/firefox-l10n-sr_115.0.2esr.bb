# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70819c7bf6f5207bb4fd770bff359948"
SRC_URI[sha256sum] = "1c243e3a9bdbddb9f96df63ca657d8600cecd80cf3004b51960671864ca18706"
