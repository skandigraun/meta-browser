# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61303d0998ec63dcf3af33d51af8f735"
SRC_URI[sha256sum] = "02f2ad55ce121e4a8221e5ffecb681b1d26e1dd5edf93d3439e342f972b036af"
