# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86017beeb1f244d9fe144720d27f0553"
SRC_URI[sha256sum] = "59ba0bd2384dbdc09152607a0d5f5c85c32d0da5ea40ab50df4b58735706c47b"
