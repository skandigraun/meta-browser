# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4316ec67ab635ff06eeeffe03eb9f98f"
SRC_URI[sha256sum] = "adce4dfffc1de56a7131d3b59b8732242eb4c60f11d86f5f6d247d9017bc799a"
