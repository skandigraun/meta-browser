# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6420e1d466348babf465bdb950845bfd"
SRC_URI[sha256sum] = "044a6ae99f83c305b414ba1056e55a993b768373c57fe0c02503fd96268b6a9e"
