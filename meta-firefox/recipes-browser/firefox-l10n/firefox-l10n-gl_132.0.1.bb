# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "47d8b459a83380c75eefc7b3293e20bc"
SRC_URI[sha256sum] = "dfa07c026feae8d9d8fd61b104ab2c8a3f74daeda6434720e0b61100d87eb78f"
