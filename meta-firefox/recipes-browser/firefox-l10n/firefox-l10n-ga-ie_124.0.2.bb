# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89b3b4b84b6365d0c29e12f6c78264f2"
SRC_URI[sha256sum] = "7b8eacf5eaf5597aab90e5252922fedc44c7819cba650c855a943423727b561c"
