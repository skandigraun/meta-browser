# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fff3a33c5b12b9eb51d625f5b937354"
SRC_URI[sha256sum] = "0fee5c00dea2c10904cc2b2087f8c3eca896ca21286849b63f0c0e33c7a4c64f"
