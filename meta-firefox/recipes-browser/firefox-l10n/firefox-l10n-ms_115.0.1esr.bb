# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e347ffddf970ed88ec1a60991e200d5c"
SRC_URI[sha256sum] = "ed366bc33cb837c80db9b6c499ee5dbfa72b624b6237a72277c09c745603067d"
