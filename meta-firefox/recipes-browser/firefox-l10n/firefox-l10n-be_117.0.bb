# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9427808f604da37c9a426d290e4bbb9c"
SRC_URI[sha256sum] = "dd81a6d50ce593d5abed231845dfba80e64641329dcfcc32c26479ef1b629373"
