# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3806a73af0fbf02db06b48d4180b579"
SRC_URI[sha256sum] = "ddc7420195a045276ee8800fa0a21743abfeeb02a2e6e8f6bd0511bd53bc61a3"
