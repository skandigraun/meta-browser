# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93dac48136c5fd152d11a4ba311ef3db"
SRC_URI[sha256sum] = "93a4955b0952613b931c2574fa9c6ed251a08df32f46304b3ead002bbe701ec9"
