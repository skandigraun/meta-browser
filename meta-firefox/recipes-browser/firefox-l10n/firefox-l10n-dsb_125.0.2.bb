# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3bded2fa40d8d557ce638ffe360f35f"
SRC_URI[sha256sum] = "7e8c3c20022cc8b3fb5d52b7e1c80059535e5048f82d0a000d7e4bbc77263794"
