# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6827f836fe95651c4ab492ea7e632ae6"
SRC_URI[sha256sum] = "1d06fb8ac92160f64a1e137f7535fb113a9a3295a667fd75663f5672ce67263f"
