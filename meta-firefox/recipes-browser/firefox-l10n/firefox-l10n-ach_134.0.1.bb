# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29ac99dfa939fd135d91558f05ce2f75"
SRC_URI[sha256sum] = "b0d5e6d705146efb8d76c6f762bb0dabed180e4b7dc414f75c40b4d6c0b4ff6c"
