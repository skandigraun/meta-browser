# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d7bdce87ab8dd0d1be2fe9185036333"
SRC_URI[sha256sum] = "9886aa09d69b2409d8ff752de53f0ebdf11fdcd39c2752aa276eef057aa68a17"
