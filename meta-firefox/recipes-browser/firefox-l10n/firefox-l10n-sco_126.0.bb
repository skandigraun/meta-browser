# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d7df982bc892d00bfe7549dc33e98d7"
SRC_URI[sha256sum] = "82b375396e0ee0b3ca6d2d6a0213dfda8078b4d53552bb94a882d9093490414a"
