# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23bc4cb816aed829280759acca6a7ddb"
SRC_URI[sha256sum] = "d4a78c2d920d8a19127d7ac952a985b32f4b4524b53e1e01d801810ee45a1f56"
