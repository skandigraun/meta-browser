# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "964592a063dab098470910677d323785"
SRC_URI[sha256sum] = "594091986e0a8651aad2611923536de3be63a1d4677faf9f4a1b9462ff230908"
