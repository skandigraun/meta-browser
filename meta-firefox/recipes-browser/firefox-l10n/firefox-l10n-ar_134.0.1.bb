# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9b7d8005e65a73349515786d9a3fea9"
SRC_URI[sha256sum] = "80fa3d96435e2d0ba92a2d7b279e02302ecda5adb68b11b869153c049a658ce6"
