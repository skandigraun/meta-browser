# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9d2eecc1a11fe6050ba32daac85234f"
SRC_URI[sha256sum] = "82aa753d989f9814fa9ba15cb79d5affb73f48fc89f0f05097a5b59b8a5e8880"
