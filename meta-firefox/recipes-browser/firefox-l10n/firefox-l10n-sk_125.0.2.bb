# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e7eee8512c94f0b5e29fc74d11519e4"
SRC_URI[sha256sum] = "3ef086b76e7ad45caedf52c99c81a3895a371666864561e683c3f127d507f283"
