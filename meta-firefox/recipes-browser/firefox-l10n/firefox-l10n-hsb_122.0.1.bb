# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0dc7b820c99ca87e2c8c523a1e03019"
SRC_URI[sha256sum] = "62679ba9df9daecc47d52a5fb169c797ebc397b992cb5d336b478484301331ff"
