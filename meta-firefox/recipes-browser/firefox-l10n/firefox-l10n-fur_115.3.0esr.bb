# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a30e96e7f7efbfd4a46631e246ca281"
SRC_URI[sha256sum] = "7dd593c07d145bd04261fa1b53e7ec35a85ffa9296eeebce83e6e49d2dc60a0d"
