# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "055762709e8a2c65fdb88b8e29c15633"
SRC_URI[sha256sum] = "b0039311630e4557ff03d4737ff3210cff889acfff63073439a834267abcf9fa"
