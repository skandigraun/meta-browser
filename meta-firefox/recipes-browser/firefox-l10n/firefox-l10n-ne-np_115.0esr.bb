# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "701d0131277e77f8511fa7c118ea146e"
SRC_URI[sha256sum] = "28e7c42ae071252bba06404ae771ff5f4e2a98c77e1da67fbf2fc7e8d7938933"
