# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bb006e60a26bc7f6261475be88af9a9"
SRC_URI[sha256sum] = "7987c088bb5555e9a074f9f2dbbbb12336d444dcc6c6c5682b9021ac7165dede"
