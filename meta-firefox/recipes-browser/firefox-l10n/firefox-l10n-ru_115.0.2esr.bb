# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e272111f1f72109aa8d98ece7a01274"
SRC_URI[sha256sum] = "5cdf6d2ebf56c2f390b8ae2bc50664b96fd4ddc03c3ebb084c3c0d3f7babc347"
