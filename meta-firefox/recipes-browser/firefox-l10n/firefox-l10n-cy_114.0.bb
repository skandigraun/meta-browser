# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca9a579c17ad507866ce10bab2881c61"
SRC_URI[sha256sum] = "aee67eb0b05c7c06b23aca4af3e473ddc75c9570a3d866675bb30c0fa409f2c0"
