# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d26956dbb43bbc654ef8783541824ca"
SRC_URI[sha256sum] = "b966d42a36d3c6035de29fdcde6e5d2c2852372105ab3274264830d714314fa1"
