# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f058e8492588af19370e87ffa889a6b"
SRC_URI[sha256sum] = "85cdf3a1e7cd859c8a7853af7e060c06a8df72df393b89e0c8ee66fef4d08e92"
