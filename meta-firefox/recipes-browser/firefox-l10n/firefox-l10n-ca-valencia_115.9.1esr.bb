# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c1b8fec0301e607802e6a765174d22e"
SRC_URI[sha256sum] = "8596e425b1b199a13e942366f6fd9c81b9d2577fc0e4b6dc684749d0a2e0e6d0"
