# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1482b1e39447c1c198dcae7a801eff0e"
SRC_URI[sha256sum] = "00f814dff6d7ffe38aa8797c9624a1266e54a4dc52f16f62612493fe0426b1d2"
