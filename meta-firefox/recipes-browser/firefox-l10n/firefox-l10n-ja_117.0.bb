# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0a8e0f77e57fb4f9b819e71d845e77d"
SRC_URI[sha256sum] = "5e4ca7cd817602562f7a36d79b0b942750c2576fb6722186d95f8a497d66c3a0"
