# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a38e98472c3b191827d99aaad38087f"
SRC_URI[sha256sum] = "89c0c2ebde15e1ac7fa707ec9d925069c2ffdd96e92a85257756f61f96b9b380"
