# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "986a597ab6e887eea61f671c6ce1d038"
SRC_URI[sha256sum] = "bc97f925b4440db0e74e818bdf420e6c9df92b6676fee7c57c93cbde61313ed3"
