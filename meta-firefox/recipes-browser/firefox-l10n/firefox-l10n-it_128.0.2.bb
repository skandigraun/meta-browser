# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51bec79f1a4882b81aa84f80d87f142d"
SRC_URI[sha256sum] = "7ead02bf440f1346d966278fb77d5b0365611b269ad06de273c40273ed8e91b5"
