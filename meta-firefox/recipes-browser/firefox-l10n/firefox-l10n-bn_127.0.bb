# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e2bfdcf12198ad48a9e8320dacc0e7e"
SRC_URI[sha256sum] = "a24623b5ed4dee93c4c7b7b60384e88b8d08ae33a2b11c0826f04cbe815d69ad"
