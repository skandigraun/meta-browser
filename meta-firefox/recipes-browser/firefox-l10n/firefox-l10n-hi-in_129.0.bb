# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94ccbb137a0c1696e936506a9adb5d5b"
SRC_URI[sha256sum] = "abc2797e07d7ae01634fcf8438fd8f756d8952d99f988b2344e5ae96977325c8"
