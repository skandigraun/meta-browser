# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7377cd5670836c08c0a36478b648d34e"
SRC_URI[sha256sum] = "5db4b3933fd6e30832f1b29da574eb4e6af33c838db564d0445f004f85ce32d0"
