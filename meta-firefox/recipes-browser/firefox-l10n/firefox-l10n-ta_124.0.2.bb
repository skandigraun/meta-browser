# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "119b236b17b01179794deb80f097d6f6"
SRC_URI[sha256sum] = "c4274e4058c3faaa24937ff44a4dd322a2a8552780c7bcd68222d29c28265b86"
