# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e0af9a1e16835ce6e5c865ddbcdbbef"
SRC_URI[sha256sum] = "4d2730e7500adc86d2a4c3cbce70881bc48afaf5b963f1e2cd6be83159512c74"
