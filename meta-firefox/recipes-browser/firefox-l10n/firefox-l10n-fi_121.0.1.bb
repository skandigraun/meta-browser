# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30a4d4f6f5833d7381d0ba1a744cffb2"
SRC_URI[sha256sum] = "0fb5392a711c3377149c68159a150d095c3ad7e4c2ac33f8079d2330e034de51"
