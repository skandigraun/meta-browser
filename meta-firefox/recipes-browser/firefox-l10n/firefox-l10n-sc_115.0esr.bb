# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad9df53dce55de2da7faa9ec8f8559f7"
SRC_URI[sha256sum] = "56abb6caa6bdafb54080b65f3671fd81793db5e7b08b7b6adb59c5973f6dc709"
