# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b039dd628f4213aa3d0a7be64dfb8df3"
SRC_URI[sha256sum] = "2aac8e9c71a1cbff136d3bcdba33bfa56d8cca44b149776aa16afe03334463de"
