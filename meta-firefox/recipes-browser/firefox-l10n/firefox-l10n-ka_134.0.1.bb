# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "883fdaa6514654121b335d7364f3b931"
SRC_URI[sha256sum] = "6b6eff355496af7d20f10be6df9f501e4fe0a088568d73751677a52b924d301e"
