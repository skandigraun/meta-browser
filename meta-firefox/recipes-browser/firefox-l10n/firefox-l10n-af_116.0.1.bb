# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f91a2686295d9057a79acbc0eb9e4d2"
SRC_URI[sha256sum] = "cf45d19c91ad5825487b158bfefc96efe6b4400ab874763c43d0a0fdaac3a858"
