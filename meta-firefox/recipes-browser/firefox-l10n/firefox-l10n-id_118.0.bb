# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3eb5576d938948c1bc9138d5388c975"
SRC_URI[sha256sum] = "e67af3c7641d5933512b7e9a1d80635581fdb34ec68b054cbb7ca74d570694d2"
