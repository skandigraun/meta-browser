# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3be25ac6a12c0765c60268dd298820e6"
SRC_URI[sha256sum] = "bf781f2794c511ddbf8fe0517ea4b12c212228998ae672543189701c77121b44"
