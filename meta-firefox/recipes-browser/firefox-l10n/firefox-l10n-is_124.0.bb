# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7cfe62ff4f0e70a8f7032059bfb6017"
SRC_URI[sha256sum] = "4c4f3a3df01939b5f9269f26780fb07400558383743e9a9f31ee6b426aaeceff"
