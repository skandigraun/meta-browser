# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "900b74b1234a7ee717c3dfe98f74b5bb"
SRC_URI[sha256sum] = "50cb2474470486720350afa33d8272571b3d54063c2bff1f716cf62964b8f93b"
