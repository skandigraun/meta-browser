# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aca4103a0130baf3136aa3b0e4707388"
SRC_URI[sha256sum] = "141c3a2d82c2ce0d36a3cc18b029bb9a263ee50b585d2ef0f7dc90cbe60fa278"
