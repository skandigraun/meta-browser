# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df5f942284f0832e9276c5c098bb4256"
SRC_URI[sha256sum] = "7276b316abff139cc2a9fb22d94024371940ebfa71d0d5d035d593222a8d66f0"
