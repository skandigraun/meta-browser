# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db21796ae620e5bc64f8d4da3b5340a0"
SRC_URI[sha256sum] = "4b54903ffc5b0b7f1060fee146a7ce72d3563bd37aa653db16a9b47294425f41"
