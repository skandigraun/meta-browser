# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d0511cfe9e845a237d32ad464c41a6"
SRC_URI[sha256sum] = "51f34d824943f16f280a79c2e8d9b4dfb6c1ff62fb2d240e2a30062748f427ee"
