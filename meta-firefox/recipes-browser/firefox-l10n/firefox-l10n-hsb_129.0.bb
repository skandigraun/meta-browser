# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51adb4a53cb42507f8d5e624c68ea869"
SRC_URI[sha256sum] = "32dd12dd82d31b3e5ad379b4b32e705836e5ddb944203dc52372a2706dd48002"
