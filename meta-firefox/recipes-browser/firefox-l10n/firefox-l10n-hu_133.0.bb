# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70e5d7000749a5fa0f1c925c06b48d03"
SRC_URI[sha256sum] = "eb5c5cc5751feb274b7385ef1fb79db871d72e099ed171538dceae2565372243"
