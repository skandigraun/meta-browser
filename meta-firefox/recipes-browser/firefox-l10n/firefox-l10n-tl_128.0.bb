# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "03372c3f6ed78aa4e82707abb7184e32"
SRC_URI[sha256sum] = "5110dbb71a397a7269dbfbeccbd2192b6463416a48f6b97aa60fa24903656ce2"
