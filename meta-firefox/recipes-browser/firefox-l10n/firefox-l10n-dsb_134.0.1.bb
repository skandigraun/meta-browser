# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa74bfc18cfdd7bd5ad15a996feb9459"
SRC_URI[sha256sum] = "b8b6a8cc217a8b9622fe1796126f5c81b4a1567b7a68449b4d4cd11dfee0ff7c"
