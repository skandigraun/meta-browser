# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e996b07be7da75d8fe17e26bc733829"
SRC_URI[sha256sum] = "6674e25196437749dda799987cd5b485f56b009f1035d053c5711e6d3a963a3a"
