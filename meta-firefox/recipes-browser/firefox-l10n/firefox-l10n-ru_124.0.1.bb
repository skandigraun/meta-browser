# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de9bf3d74f1cebc61233138e504fb09b"
SRC_URI[sha256sum] = "1ef0ecee959abb6785d8c989e880c72348d6f137bf197d204efc70d51b059259"
