# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48ff4ab6ac02c3cfb1017bb28b8b102a"
SRC_URI[sha256sum] = "23342aa634042ffe739290e6bcd02bb39d0b257c31d9d0cc14cb81c6431e33b0"
