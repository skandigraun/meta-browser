# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf3a4efc6c03c7b21a0100eb794af6ce"
SRC_URI[sha256sum] = "f4040cd367aab421229f1c76c25db4ac80f30d160f0710d873aa838a5ff779a4"
