# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c0bdb055482c09315a51b952240248f"
SRC_URI[sha256sum] = "3d46ab3d250de90e365c2610ffe35c091d46f097d5de0688305bec6409eb1606"
