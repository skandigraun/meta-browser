# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5da7b867ec34b3d5a2e153e0bb0455c0"
SRC_URI[sha256sum] = "e1e805fd2f85e7e1a7708500d69afe0dee3decd777a41f205981adc36b7a672f"
