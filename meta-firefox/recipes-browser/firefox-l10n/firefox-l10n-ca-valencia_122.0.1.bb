# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41468c110595e90d2f0d4cc1f4921c90"
SRC_URI[sha256sum] = "a2d1599da8dbb076c98a577d2a134588f5ea0aa70b8ddddb3b1f0ce35670ffd5"
