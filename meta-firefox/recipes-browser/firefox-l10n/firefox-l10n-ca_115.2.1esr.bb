# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e57ba96c7d363b85448a049e0dff26a"
SRC_URI[sha256sum] = "4d9cdce818dc7c4a4c52d4f20e2146f00b93c0bae5370d36568fba4a4f527dbc"
