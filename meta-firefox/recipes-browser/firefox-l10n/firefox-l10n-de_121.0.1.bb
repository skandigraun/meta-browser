# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "277693e5e81e1634e9e47e15a1b4526c"
SRC_URI[sha256sum] = "9c76f0f42ba7ea4a82a24a3d2e4dd208c9eb0fc711be2cea1e9dabc7f4887c01"
