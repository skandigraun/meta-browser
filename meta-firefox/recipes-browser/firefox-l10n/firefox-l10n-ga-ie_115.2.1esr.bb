# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adde929ebd48d898647c18ec62ebaba3"
SRC_URI[sha256sum] = "7077dae6a777b25a411c274216170ef54b608d18824cf73f5a99d38f3fcd892b"
