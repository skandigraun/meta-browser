# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96c45965901e8f49db5b58540ec36aed"
SRC_URI[sha256sum] = "0be2928ce1834a9dc4a695876880bf1271c4e0e67fa05e59ad04eb76e6ce2619"
