# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06670c68bf157aac1dfde2659c2636ec"
SRC_URI[sha256sum] = "f4adf910145c154f5cf50f2738f16dbe803676b5bc3e33e9fa912dbe2f46b7fe"
