# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "459e2e0854d35d8b41e50b43d59440d5"
SRC_URI[sha256sum] = "0dc7c512afb2b2d23e998f64a87db9dc43b4784bf02a49434f85491b42960d58"
