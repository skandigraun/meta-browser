# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7db9d1a51947615255919d35fe4906d1"
SRC_URI[sha256sum] = "ffa46ed722aeee530e8e2e4910d73fcffcc4cb0d9e05d609119bc7bfb3d61368"
