# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b65d90fbef2385e1ae3e19059643093"
SRC_URI[sha256sum] = "90c7dd68db112e05879d8dbf57b49bd675097bc2117a0e223395a253027d7595"
