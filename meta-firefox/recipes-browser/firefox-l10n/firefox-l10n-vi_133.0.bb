# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0ac0180a8c9f0bf16dca2639dd774db"
SRC_URI[sha256sum] = "294344d981092a9eee0278e8d6e6fe8439e37d9659d5c6f1add915faab20aad9"
