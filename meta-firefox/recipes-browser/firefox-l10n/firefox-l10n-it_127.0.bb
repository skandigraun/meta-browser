# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c50d5f507f4a468334496188bf0e3b3"
SRC_URI[sha256sum] = "f285dff11f915ca3113957a71fc7ac312a0330c303f0e20fd7b2576b8132522d"
