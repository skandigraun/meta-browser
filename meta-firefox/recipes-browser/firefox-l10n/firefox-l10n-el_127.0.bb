# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "425b4277923f1347b508626675537a57"
SRC_URI[sha256sum] = "85134a3e26725a543a089d10b33723cf991ec913f8f65a12908aa76c41725e82"
