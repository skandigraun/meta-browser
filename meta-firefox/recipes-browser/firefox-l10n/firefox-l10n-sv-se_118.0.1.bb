# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "021aea32ca5a65cdd635b07a84faa72c"
SRC_URI[sha256sum] = "a3ed2ea0741f2e9f4bc970b758bdd507edca2f0e6e594c140b86bea25435dc15"
