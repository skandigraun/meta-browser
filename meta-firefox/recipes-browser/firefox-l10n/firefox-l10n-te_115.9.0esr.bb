# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c509d10e78c0d0a7aa7629ca8e43bfb7"
SRC_URI[sha256sum] = "757e04082e3ad318a5833ce514110a1a124c0f1ba169a0cb1a3e87a9f6c12b0a"
