# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f24e863920678a595eea03466a6803f"
SRC_URI[sha256sum] = "70e4bb13ef75a26baceb15dfa78ff581f1882b49ce27963ed7066b8d44df41d9"
