# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20720b3bc1d017725f5506d96c4155ed"
SRC_URI[sha256sum] = "a316189f9944b5525f05d081fba74932ec1a81f8df5bf9d1f632c5920c051bd0"
