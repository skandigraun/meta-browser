# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "276d1af70a3de8a8aab317d92b5e0c28"
SRC_URI[sha256sum] = "88ac20e24ccbc6fd10ab9eb3f42364350142b1ca53b8c77b40e6ae96857cd362"
