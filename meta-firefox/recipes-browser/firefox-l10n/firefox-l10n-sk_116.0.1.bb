# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59551f017a635e4a0010c30118f807a5"
SRC_URI[sha256sum] = "72a49d85058812a9217a84e19a04e775e07a89176f2f5422affbb091b938e3a3"
