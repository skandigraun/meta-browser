# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a15426db3671498bdcb0ec3e2eaaf12"
SRC_URI[sha256sum] = "21587e5c4c076da0ca8e97dc1748c1bd2695f74a4a48b9a0f764fe0bdd2511ac"
