# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "778146a70fde1fc0c49ab2b6cfe12f55"
SRC_URI[sha256sum] = "e903386f142544c4340dd5cbe423d5f3c3c420fb449a9a7332c992753128a6b7"
