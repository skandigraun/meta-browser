# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e461fc71540bd4c6b6a95715c7e8b99"
SRC_URI[sha256sum] = "4de54fa74ca03fc03620f0bfd4e8d9d111553431b38aff225ae223e42616c07c"
