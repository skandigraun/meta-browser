# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cea9ee0d9d6abb89d3e021de5d611846"
SRC_URI[sha256sum] = "57bfbb60a455a2a30e60e78864a5a6a57d9043ced45f871774a1353fc4aaee96"
