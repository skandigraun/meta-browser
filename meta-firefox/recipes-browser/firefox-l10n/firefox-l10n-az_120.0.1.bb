# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70c2bb93987b22464c63c58c4f2c56e6"
SRC_URI[sha256sum] = "f03cd0135bff206daaecc6eb931e578349ed413b07c4e46bac5663893ef80e8a"
