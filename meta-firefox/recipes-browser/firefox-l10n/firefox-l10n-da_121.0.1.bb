# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92b09754d5b9b445ed595a16aa546999"
SRC_URI[sha256sum] = "4b8431278f497a777a05890f02a82c803a2b4698fe2011805171715a721825e0"
