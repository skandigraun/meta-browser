# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db932bac00fe3832c88bbd2231c800c5"
SRC_URI[sha256sum] = "d7b1cf15ce88f3c6e80575d310d1fca0424abb33a716f37a1d2ba160c43fbb33"
