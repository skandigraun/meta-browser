# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6f378b1c62297e1c3b0d163f4f73872"
SRC_URI[sha256sum] = "1253a66cc2cb0c7ddc9dd33014eb2db403b28cbd16eda712231410beb366ccf1"
