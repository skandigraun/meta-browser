# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f448bf2b1be0200ddfa3f58873990065"
SRC_URI[sha256sum] = "7aaef595b6798f04cf82cbcad56c877ad231d23553931cb9b65fd32aaaecde69"
