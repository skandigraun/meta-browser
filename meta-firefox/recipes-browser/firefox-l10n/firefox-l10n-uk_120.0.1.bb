# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04043d94df632dbbc1ac3db4ee034d91"
SRC_URI[sha256sum] = "c785c2adfd2d97d952f07418a4266c71cfa442667d5cf00577d639f95e84483d"
