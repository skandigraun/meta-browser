# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e77530bfb923ae341b7202adbead48cd"
SRC_URI[sha256sum] = "c98fde219a3ec4163916cc8d619f32a6a5b424edc16b3dbb74f987e76bd15adf"
