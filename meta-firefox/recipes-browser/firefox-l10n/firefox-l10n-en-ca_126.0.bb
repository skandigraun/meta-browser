# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9260d1ef287cdcd4271753aa99dd837c"
SRC_URI[sha256sum] = "175e0ca83149778065851a4406ae76f566c432525237f9e14136431234f820ae"
