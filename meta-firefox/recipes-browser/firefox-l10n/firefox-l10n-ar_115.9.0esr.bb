# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e5b0a4b706ceb3139d37217f0ce7fd2"
SRC_URI[sha256sum] = "593d262be9ae3e0c955e85ec391292497ee7bb627de2ef48eaf34cb3889be4e0"
