# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96a7fb8b5bf402b475cecd4d8239bccf"
SRC_URI[sha256sum] = "9096d14d7712156a4b5c22559eb88f0248a42ed9998108166ea1f080b981b945"
