# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23e8dadd4d6cf7c20a7875e720607f92"
SRC_URI[sha256sum] = "371562ffdbd5c077e85e2bd2b42d45f12eab6f0790c0431639bb7a714fea7a90"
