# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64d3b8ea57af6cfc3f126e8d436b3987"
SRC_URI[sha256sum] = "be9cabf52742cc7eab143e1d56342c019f03ddb0bf9f4e3a3618821091b786f2"
