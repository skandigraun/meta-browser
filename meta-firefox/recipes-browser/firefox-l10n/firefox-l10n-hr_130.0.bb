# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "800b54d554c3c1555a1358ad9304d7e6"
SRC_URI[sha256sum] = "56663d5709015a437a9656447c50059e2d4842af3b2a450eb814363cd70c6855"
