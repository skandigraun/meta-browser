# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f388462e108e26f1ad1abc74ff1d2673"
SRC_URI[sha256sum] = "514f2039194909fcb74934c4933bc8a0e37d1d26614be60f974660edf5f66c44"
