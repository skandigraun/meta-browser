# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa659e0f0c56f12dbae0c9bc2d4fd12e"
SRC_URI[sha256sum] = "4d5f2ef37cd14dd387bd59908ada474b8b601f23a6fef58ed9fbe2fee71cedc8"
