# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c27069bf998ca51a50e50ca0e13f10"
SRC_URI[sha256sum] = "fc1c014079c87ce4e9d48dc208962eb9809bb92570f7943218a4145ddb56980e"
