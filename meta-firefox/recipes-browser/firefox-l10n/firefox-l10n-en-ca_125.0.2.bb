# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7f150946e7e65bac62889438f6a0cc3"
SRC_URI[sha256sum] = "61afce90bf720d9b765ce9036015fc8b30123426b16fb99762205a8fb1bdd66b"
