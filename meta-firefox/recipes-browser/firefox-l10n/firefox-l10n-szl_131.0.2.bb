# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82eeb2f553f369c1a17f468fef246df1"
SRC_URI[sha256sum] = "bb3b71dbf1cd025761e4dfa64c9d471af3652b9d44cff09f53cec71ddfe1fa4c"
