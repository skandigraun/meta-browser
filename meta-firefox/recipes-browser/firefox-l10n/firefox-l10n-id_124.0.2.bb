# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4e909927dced2af1fe211466b3496d7"
SRC_URI[sha256sum] = "a4c735a5cf1119888f28c07cf124d6b56b4c11e60336afd7a191a7f77707172f"
