# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9a623335e4955bb7281942339e57e22f"
SRC_URI[sha256sum] = "2da15974ed5286becf8cf718314978f72e06930b2979994190fdc4c2aa122478"
