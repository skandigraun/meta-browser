# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "282815531bd73df06760ecfd51b1cdfa"
SRC_URI[sha256sum] = "527e4ade255824466ab76d0c105ff50122b15fde09c1ef8fb30f3e5d276e1a57"
