# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "455fcb93e3093dbf56b7a3102c985ccc"
SRC_URI[sha256sum] = "e7d06db9ec3d50d0e6a76eb26a0c0ead99aceb8aea050530741c4e7ae9ba74f7"
