# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7c9ff0db6e11ee3d1646e2ab4a769b9"
SRC_URI[sha256sum] = "a024aaea3aa0ca3d15050b91ce95cab477684de77d81a599b0145797650e9b83"
