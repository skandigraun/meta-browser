# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1169b093126bd7b09ced4975c4a73b0e"
SRC_URI[sha256sum] = "fcfc6504f9661a2f6706149e5ce0a9c152d8ab1bdb5a5c65c4d7fd906e7e0e76"
