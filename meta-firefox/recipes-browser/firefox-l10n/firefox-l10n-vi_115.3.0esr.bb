# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "94784d96d555578b97fc7283a6c69cca"
SRC_URI[sha256sum] = "f8e835327a3f3d4d9c12b1893a5fb2ba924c59dae0927ede5832978984fa2f12"
