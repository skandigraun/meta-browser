# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ccf70e293efecf28b97567ae53999b6"
SRC_URI[sha256sum] = "49795ed3083757a880dfe98ed105f0b64af40e7db4c96a9091bd2b86b2d742df"
