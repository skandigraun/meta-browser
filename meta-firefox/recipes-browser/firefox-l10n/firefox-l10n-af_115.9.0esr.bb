# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b6c703024e05315c833e880e6e54fed"
SRC_URI[sha256sum] = "540b493490846ec0b88b37ad5e9e0a295f3199fb185a6a86859acec07a4d1ddc"
