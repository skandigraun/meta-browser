# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76b2c73834684f14c8ab6a10fc9d667d"
SRC_URI[sha256sum] = "c5e48fede4d0a25b038bdd4b3379a67d81eaf9f11e1e96bd990330e892293de1"
