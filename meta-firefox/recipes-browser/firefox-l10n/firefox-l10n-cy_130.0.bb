# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1dfbe7f25482d780c6656f523062b06a"
SRC_URI[sha256sum] = "c4fd7274e7461f82f0e8fcc662a405cd15cf8b57d856a10517682b4da025e61a"
