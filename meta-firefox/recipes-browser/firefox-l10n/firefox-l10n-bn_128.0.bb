# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d69188da24a335cd70e46a91b27e070"
SRC_URI[sha256sum] = "4a306daed986327cd6e286ab1a1a9d85d0db033288902dbce280e9030bba1d84"
