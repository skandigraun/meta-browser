# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8ef3e375bda79679dfdcefa020099ef"
SRC_URI[sha256sum] = "a28621712a804a38272710ef9000259498ae94202f984b7b4077e893adbecd57"
