# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b3c58ec97b5c4b12ad1f2b497dda5c0f"
SRC_URI[sha256sum] = "9e01a4c88c96925367bcd5af362d17e681cf67e0fa00eb71f55ceb7bc25d19d2"
