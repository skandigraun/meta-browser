# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cddc3d85597aba97b0aa38a744a692e3"
SRC_URI[sha256sum] = "06badd927a3a7672340bad81a9dfd574ab953b9df18591b8c94a492197e477ef"
