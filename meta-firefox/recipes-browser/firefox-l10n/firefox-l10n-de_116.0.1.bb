# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f187b98a7753cf5ad207cd943552b68"
SRC_URI[sha256sum] = "2ae3add28673f09734b74091fdad5ce3ea993a7f8711a83dc3dd3686facc3c5a"
