# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3560c15086b9788dc6f18fd5ad4604e1"
SRC_URI[sha256sum] = "834ab7acc33124d0b41a71def5f2dfbc20ddb6c5d385129ec2e45160fdacd597"
