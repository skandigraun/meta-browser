# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14bdd7c8b452c29cd8e1f91635f353d2"
SRC_URI[sha256sum] = "6897a9f7653e3ff2dea03d5d8192daa59fd393b16dd2eecd6b118c574931ed3f"
