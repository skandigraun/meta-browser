# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4d14d03ca7435ebd68e8dc95932e6f8"
SRC_URI[sha256sum] = "b3ee7429d9ec5ade16668145bdae9a477172d05ea961f556de7ac8d759847070"
