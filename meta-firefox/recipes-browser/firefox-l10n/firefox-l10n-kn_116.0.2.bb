# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9300948eded93bf81bae664cd42660bd"
SRC_URI[sha256sum] = "32a28d05e8caf1882954c11c6f5fe21cebc9158d4362ab0f034b344c7cb9aeaa"
