# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1403c19618c0f11a8b8d8fe5b8581e0"
SRC_URI[sha256sum] = "f058abe1994e84b5f9b40ed2fe082fc3b8ccee9d4ab6f150b29c1c975b7cc5d7"
