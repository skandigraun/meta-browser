# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffabfc421d3132919bffab161d7c2f31"
SRC_URI[sha256sum] = "53d6982d91557b293eb9edea28428126ff33af8ed022a4e2fe1dd6f150e7afb8"
