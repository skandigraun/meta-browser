# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21b57464b45d5690acbf24b1d79b3409"
SRC_URI[sha256sum] = "d118911270cdf6eba112015b8863e65a96da8bafdf0bc0c31fe5eef65e1fabdd"
