# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18526effae0f8d71637134383f538c61"
SRC_URI[sha256sum] = "2fdbda7f241c601484df32a2dc48d74d8316ada30e5b2ab14ffb13640114ef5b"
