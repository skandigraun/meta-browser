# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6c4e6ef6943e5c53b2c34423c30c7ba"
SRC_URI[sha256sum] = "d0314c34eac7ced8c22b0b72a5bb8e811e3c1107f170dd63547ed83346458500"
