# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f511e418b7f69bf6ce81b14712672a1d"
SRC_URI[sha256sum] = "66f14f17b984cd85c54b232534d772144dc1fafc09dd398c7013bed496c1e8af"
