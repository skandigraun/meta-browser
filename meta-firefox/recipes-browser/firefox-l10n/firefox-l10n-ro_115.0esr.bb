# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22d39b66dbe33e618f4183e894cd54f4"
SRC_URI[sha256sum] = "d7721e2422cffd62b8736574457bcd8f3f61003f60da27b6c7f064972ce86b45"
