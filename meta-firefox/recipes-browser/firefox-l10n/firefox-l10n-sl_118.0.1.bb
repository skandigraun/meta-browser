# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8d155623b6001f71415f0d8bf6c3aa4"
SRC_URI[sha256sum] = "5d2944231f85331bbf5336b38742a3f803dbed038617eb31d921d80f7d7782c8"
