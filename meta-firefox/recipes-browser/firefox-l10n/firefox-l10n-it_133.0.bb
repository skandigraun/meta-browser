# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f150c60bcebcaf08a7dd21b53da83a"
SRC_URI[sha256sum] = "cca30798ae0fa6c9f4351a1daea57cfd589a769a6970be40f8606fc82ff6e00b"
