# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f1b08d8916c8e1dd7b5e662f9670462"
SRC_URI[sha256sum] = "ce45c5ee9ac273d792f334326f42ab95212b228942e6c68a63e87a77d23f1771"
