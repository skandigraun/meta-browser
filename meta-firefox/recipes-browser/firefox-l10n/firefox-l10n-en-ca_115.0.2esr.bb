# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fbb6a6dfa0665fcfa360979230139e1"
SRC_URI[sha256sum] = "ed0b5b05a6ca6b1581960683a178c9cbf0d7999bc77359ad28e5ee3adb3191e5"
