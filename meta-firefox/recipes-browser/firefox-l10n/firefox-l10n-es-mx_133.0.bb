# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9923e4b3d77e04842088d092300df281"
SRC_URI[sha256sum] = "2b9dc8a78b8ed1b61beaf529339937ed624ccd2b34944bcf0435f7017eb20922"
