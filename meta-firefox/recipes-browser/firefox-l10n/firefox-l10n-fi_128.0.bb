# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6d4df5fd89a4fc4bef9e4fad88a01a6"
SRC_URI[sha256sum] = "f977a1335d8d5211c98c747f744c5259cee6e3493d07d7963b07ecb1b6179c70"
