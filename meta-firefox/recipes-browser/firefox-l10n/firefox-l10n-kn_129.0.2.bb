# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7ac4ca594a33f201e85801b1e3b122a"
SRC_URI[sha256sum] = "454ceb43d7e67cc1a31137c020148ab1a6810de23d5b880089f884975ba83729"
