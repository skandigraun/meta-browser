# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45380ba1c568e621f0afe5bf80b8d0db"
SRC_URI[sha256sum] = "f8701ec3293b1e9d8c14e42b3dd9bc9bc4a1ff8f887b0b7bbfa8aad965a610f5"
