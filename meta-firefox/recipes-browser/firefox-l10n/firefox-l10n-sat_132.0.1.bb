# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48e5f0bd99f5588f1a18433f8ddc7a08"
SRC_URI[sha256sum] = "aafe0b2127f9f6c5172d0fbb5bca74b37f3f2551d5732daff5dfe7ec10239831"
