# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e834a3d26354f162324317596f091664"
SRC_URI[sha256sum] = "157cf6ab14929fb081dd0adb8b9e92aa7a89e3e2b73404c284cd57ea6c54a165"
