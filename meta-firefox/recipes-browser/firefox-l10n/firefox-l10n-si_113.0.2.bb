# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f5cb4c7d6251ede8ec42db79516dc83"
SRC_URI[sha256sum] = "11e5ce5b405dff9737e31ac36c68f64f223ae8da052ca0d5663a0ef817ec7975"
