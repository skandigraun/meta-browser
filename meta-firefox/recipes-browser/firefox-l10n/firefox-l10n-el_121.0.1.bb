# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "766e61cb9f179bfe558764f83002e5be"
SRC_URI[sha256sum] = "76603bbe8a83ffab0b12e2227ee43b2cbc8bef0dce080307046ad4cf9b122bc4"
