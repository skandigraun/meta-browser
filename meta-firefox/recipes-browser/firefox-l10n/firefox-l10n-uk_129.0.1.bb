# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79f5f491fb45b24de9eb916e34485949"
SRC_URI[sha256sum] = "df1b4b42b6d41538a80f61c877bc716615a0b79024e45197ae729939943f04c4"
