# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3169563597cbd702d4c88576723d8b0b"
SRC_URI[sha256sum] = "10b0ca0f478f844e9a6229a771c1d480cd45bc0cb69a665ccc41a565daf668e9"
