# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c19c8a0d876d8b42dbfba93467074e2"
SRC_URI[sha256sum] = "802537e360788ec58d697c17cd0333e8fcfc92ce3161d19cedc2a4841825d0ca"
