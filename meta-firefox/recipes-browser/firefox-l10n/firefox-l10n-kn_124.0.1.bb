# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ae0bf6921a9c5f5b4dad92ffa2a2c3c"
SRC_URI[sha256sum] = "9654157303d638bf3b1d5adcbfba65109849d97fec1cbde476c380a79c9e0a9e"
