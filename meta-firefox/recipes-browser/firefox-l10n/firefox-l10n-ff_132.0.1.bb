# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7bbb56c0152c3ed72d37dc93cb3f204"
SRC_URI[sha256sum] = "ce08bded154882a84f90812c49805a3d4f64cff9af8d8aa9035c4b333555320b"
