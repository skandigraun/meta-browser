# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69f68ad5170573b89e95eb1647326050"
SRC_URI[sha256sum] = "b5733f48ac3d512ada906e24913c804d8dab881215b0c2458c1eb2da430aacdb"
