# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95cf5ce8cd4405f651455fef71a859cd"
SRC_URI[sha256sum] = "96ed67ce3317d37ac0cfe1e73c6517d9e657939a6e05ae782b1a4b40468132b6"
