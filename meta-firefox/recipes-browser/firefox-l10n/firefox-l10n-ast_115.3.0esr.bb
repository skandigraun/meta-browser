# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cd3167930f10a7e237794a7a7c72d03"
SRC_URI[sha256sum] = "ad89ef0a45deb3797283ba10f0804d1629e590005750bbd8a3ca61f733bd7397"
