# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c036200faed5cedb07afcc2ce430c77a"
SRC_URI[sha256sum] = "6881750feb372b5ddfd094451a10be5ce9d5de1cc9955777fe8354ea6386cd5c"
