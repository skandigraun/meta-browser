# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b77b8f54aea94caa49f1f623e6f0be10"
SRC_URI[sha256sum] = "8fff7265ab05f97dbf64af952be1f578b711daf86d75471fd891e79fe10f30de"
