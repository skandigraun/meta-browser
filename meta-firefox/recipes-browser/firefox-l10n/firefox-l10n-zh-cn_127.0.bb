# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a132d51c1e4d288c3639fe27a0c21fe"
SRC_URI[sha256sum] = "cc28174d74153c47036b23564a87b0e3027face0d9d8b73eae8ae83bb2ffb513"
