# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e97787e4427e22a8dd9c05c357c2b3"
SRC_URI[sha256sum] = "c2090023a79c68cb1b5929acda03e4d9909ee57f090a3969962ab4f269ced493"
