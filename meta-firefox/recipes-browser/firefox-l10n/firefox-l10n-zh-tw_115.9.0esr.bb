# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2ec57e604ec2261c1fb88af6a2fcda2"
SRC_URI[sha256sum] = "5b1e67d2290cab9ae70fb384db8c4428473a49dc6c7d141746ae23a8c845c7e9"
