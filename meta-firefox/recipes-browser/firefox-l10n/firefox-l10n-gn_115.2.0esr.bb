# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11e25674a3db471406eb1073168b2d6c"
SRC_URI[sha256sum] = "b5afe5729a6a8fba9d63e427a92d45f5dbcf9b31e2b01518a812fa140c92717e"
