# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "234ccb84f69a3e27b4a81883b9e59032"
SRC_URI[sha256sum] = "ceb8985d065c5a8e7c88a547e5c5047b2e3ef8775f480b82d395b2752d31e425"
