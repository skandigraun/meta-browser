# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc8899fcc162fbdc7e263c0984b66eed"
SRC_URI[sha256sum] = "0ce17f4f548084bc66b4c4339d8ce731d806d970558be66c03dc933ec63694aa"
