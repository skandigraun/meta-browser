# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bbc62eb8e674be091020131d77fb0ca"
SRC_URI[sha256sum] = "a27b092afdd7ea862f3afbd8d3215a38aff9e78640fbafd4d82701e1f6eba155"
