# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5864ec1cf25f9aef5d01745c549aa54"
SRC_URI[sha256sum] = "47f6a66a1838189464b5fa4ba7652d7eab6204898ccf4ed50efe49f18f7c9005"
