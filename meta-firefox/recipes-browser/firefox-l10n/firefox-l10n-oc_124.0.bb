# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd513ab747f4f803352b7903ea3f5a3d"
SRC_URI[sha256sum] = "45f7ab178a99c425660e3c4afc76835616679b131a26f1691f9b50bb9ac20893"
