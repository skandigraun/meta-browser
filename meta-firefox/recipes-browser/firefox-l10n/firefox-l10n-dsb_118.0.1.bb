# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "440a0cbf9ba94635da5d6c3896675ede"
SRC_URI[sha256sum] = "dac83f550dedfeaf45a0d33988c21aebfef170094f8173525d82a33ca88a2f22"
