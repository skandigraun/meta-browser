# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f63438f3effcba13115b55a89671fbfa"
SRC_URI[sha256sum] = "0d87e375dbf10dbb20558c3eaf52beb32fc1fec990008eed90491c9418c8ddfd"
