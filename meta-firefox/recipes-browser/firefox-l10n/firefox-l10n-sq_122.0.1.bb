# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "635bca1639fdf87b1e43cdd4fedc6155"
SRC_URI[sha256sum] = "604ce14ef17ee48aec623f6423668b24904076c17f595ad57d7a07da3c790412"
