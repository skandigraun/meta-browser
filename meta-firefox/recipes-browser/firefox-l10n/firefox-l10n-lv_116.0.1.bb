# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4203a2c02d77e12f804d1ee488d81ff8"
SRC_URI[sha256sum] = "31ca3c3086855ab32587b1fdcadb48da9ba9ef0fb942c92d8e72c4fe756c1b4e"
