# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c23d95f03ff1839881f10985488c96b"
SRC_URI[sha256sum] = "9c4777fc1e3df9f971852e15e273867c5305579e2fe3cd620ab25c993ede7f12"
