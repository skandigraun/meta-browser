# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5fa1952e5b1e85cd9ab090aabe4e186"
SRC_URI[sha256sum] = "bb44599e8083467c1abdbc485a3b3df477b09251e19e5270468262e41f5a5cd4"
