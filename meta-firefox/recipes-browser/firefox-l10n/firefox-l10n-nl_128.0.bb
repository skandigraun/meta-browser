# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82ee7399db260f4624171ebc285dfc13"
SRC_URI[sha256sum] = "2e4e79eabc5f44d5a1e688fd2344cb8666b2e1509a33895580743267fbd75476"
