# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7d0456b07460c857799e5e604d9f2b0"
SRC_URI[sha256sum] = "7002c8fad31b533bb1f616b3443b41b72bb27bba7d446122ec95b3b41816a29f"
