# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b379106f9c24d017caf232e7425dd40"
SRC_URI[sha256sum] = "d05f95e6cccec8895ec2b6d71368ff24eb234c253150fe0cf079b70f8e6bdba8"
