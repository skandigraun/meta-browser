# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee21c100a46922b86b660123cd7b821c"
SRC_URI[sha256sum] = "e04b14e6207956283a6390bf22ba61f81eebecb412ad85e797b66868893a5cbf"
