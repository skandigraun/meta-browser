# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29a019c92e49961a709006db287d6d3f"
SRC_URI[sha256sum] = "15f0b5494a97bebf727a49b17c2bd0bb0aa4e2a92bd2b4e045f3a7c658d04720"
