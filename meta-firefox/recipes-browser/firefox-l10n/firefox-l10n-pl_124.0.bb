# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8660f29a949eee48e63ac75d2d814471"
SRC_URI[sha256sum] = "118803b2a0e41b7fd03a1a17185b38b43b3cfb7e3082a2eb8128b3832932542f"
