# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8d85e7e57f821f31bb3ca1bc8d5f7c9"
SRC_URI[sha256sum] = "51f8a6aa6574422d4e91beae18e84b5fe25071f61a83a079e77da9ab84f1d128"
