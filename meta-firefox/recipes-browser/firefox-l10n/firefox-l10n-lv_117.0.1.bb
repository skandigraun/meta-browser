# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a285c8be2f7eb9fdd4f7b348c6f5c09"
SRC_URI[sha256sum] = "418d2765db1b2a8c147dcaa40e1c9ed522e6830f26fd12b32ca2fa3a57ac69f0"
