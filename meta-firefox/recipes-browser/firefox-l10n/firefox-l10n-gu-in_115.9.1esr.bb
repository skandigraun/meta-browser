# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db5f60fdce9b2f578a1baa0dd363555a"
SRC_URI[sha256sum] = "7a02c0bcacf1ace94c495c372d3d6ab1690c160f71736dd801d8d0c4a73e7738"
