# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3854455874641bbdc47eb3f5b5780223"
SRC_URI[sha256sum] = "19d32a1e8008874ca61614850a74b2e20623252d18695333ff5a9af98a0e65f0"
