# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84185b589a8a7c3042180ba2b6164a05"
SRC_URI[sha256sum] = "db0676ef47d72c040460298871dfe420ef56ca9ee8dad80c066b1e5a5687168f"
