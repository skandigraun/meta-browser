# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4457a80e66fa065abf5998b73f61681"
SRC_URI[sha256sum] = "199f2520aa00e403bb291002ecc6cdbe8feb1c8aa63972502051afe764244cbc"
