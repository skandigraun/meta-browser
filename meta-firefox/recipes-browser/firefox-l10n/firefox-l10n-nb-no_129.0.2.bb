# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bdf867c22a2509219a5477af5ba911b"
SRC_URI[sha256sum] = "d42d5cb92d84816d639ae1561ecea1b0c6cfe57e723ecdc073fbd47c3c61cecc"
