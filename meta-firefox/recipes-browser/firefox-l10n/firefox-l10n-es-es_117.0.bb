# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02318a5c4fe225384322e4e234d2e719"
SRC_URI[sha256sum] = "8b0c1715dab4d3d6eb5a7851c8759ee49a1fec26c62ab2356385e48aad717832"
