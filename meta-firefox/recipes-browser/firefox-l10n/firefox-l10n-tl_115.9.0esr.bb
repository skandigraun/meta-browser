# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cc83f790ca05749eb168558a867e167"
SRC_URI[sha256sum] = "07365fbb840d5f1a5eef38a063f6b4698e2e1562e33b3a8761143f6ca07df0b9"
