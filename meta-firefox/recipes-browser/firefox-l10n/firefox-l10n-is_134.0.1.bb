# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8870b31d73e4b1a10c892fb287d56af"
SRC_URI[sha256sum] = "985b04cf08e55559012e16acc531511076103e4a111efe4f462a0467ba03013c"
