# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a3d9ae2b13a7a9515d4ca61fc0b77d4"
SRC_URI[sha256sum] = "3683239408d530e899d399c92555dc1fd7fe38a59f3578e90839d11dd5cbb805"
