# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "257241efbe9693e459726e491008ee24"
SRC_URI[sha256sum] = "9f5f751ad4b29ee59fe1f4c4062cf2fee377d15b86420795210c66dc631ec751"
