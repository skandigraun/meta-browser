# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df1c725bacd38e7240834a51c12ad995"
SRC_URI[sha256sum] = "c07d941472891ff9954b5d0efd6a63bdbd5d878110345480b188793695f0649e"
