# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eaa2932b0d78a9ed100afc7f8d6aa94"
SRC_URI[sha256sum] = "91a57f96850e95a7e8618a2fa74785227344d919a00f27c4ddb8b820ccac4ac8"
