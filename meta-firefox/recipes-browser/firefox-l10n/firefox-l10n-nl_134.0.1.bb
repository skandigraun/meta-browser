# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2bd62825399fb0ad89becded4e3edd7d"
SRC_URI[sha256sum] = "da50f9f575dc7b7538377df56b010284cb61f210fbbee766e727da64488e7527"
