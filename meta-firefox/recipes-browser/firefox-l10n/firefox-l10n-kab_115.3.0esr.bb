# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc1829a2bd409ca378ba97442ae6461a"
SRC_URI[sha256sum] = "8c35177c25f1bbdcce429b23270db4731e5b8a470f965b8dfd79e74fa7155987"
