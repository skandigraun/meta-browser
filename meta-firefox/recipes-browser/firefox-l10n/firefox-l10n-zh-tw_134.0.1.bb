# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c8e817ace24765e8faf2dda91bb2cf0"
SRC_URI[sha256sum] = "5e2f9efd6ed31a313beba2a8a3e728c29fb3913dde7abba4df9d00e02841edf6"
