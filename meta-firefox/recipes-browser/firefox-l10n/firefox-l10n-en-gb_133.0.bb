# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04cb35e365ecd091dcd3ccc0bbeb2530"
SRC_URI[sha256sum] = "4ca1a741f47e2bb2f9847b85bc377917cf9655e25d9f30df732c87d89cd76390"
