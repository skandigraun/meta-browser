# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00e9a4981ae6b40bbbf7f8c23b2816cd"
SRC_URI[sha256sum] = "7f97378e7301feb6b11505cf8778c968f4230290a119581194c2c2d67f0c5409"
