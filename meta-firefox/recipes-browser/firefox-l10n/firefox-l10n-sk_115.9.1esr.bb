# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50df1742bb9e548ca52006e2163fd5e0"
SRC_URI[sha256sum] = "b534d73f8a46207917abad322c1fe349de14e73581e7a51c7cdf30752f0c5721"
