# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "121c3529658a706286f786ea2c613820"
SRC_URI[sha256sum] = "3c3b17da4d2f382f1bd1ea7bfee4101b8c86083fb06a1c42877994d9ce7d58f1"
