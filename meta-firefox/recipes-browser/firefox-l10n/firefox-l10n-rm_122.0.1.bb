# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1c6217f189f4ca12e39e32de94b21dd"
SRC_URI[sha256sum] = "957f2fbd9d530dd66b54f1eb1598ddccff8b4657de6efe3113909bf3f43c4bae"
