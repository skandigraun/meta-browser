# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceac015cc0714b0ac6975fcdb8904e47"
SRC_URI[sha256sum] = "7b33f17e219121faf0290ebcc2f094ccd91ded0d9209427eed561a27f698bd25"
