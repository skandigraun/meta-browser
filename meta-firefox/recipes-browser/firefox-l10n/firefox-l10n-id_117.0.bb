# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c62e70b4e8b67648d5c7cc2eb25a11e2"
SRC_URI[sha256sum] = "07194a86c60db0e8dc1dce300a803e13d690de849b7609fd6b0b2abc27777cf7"
