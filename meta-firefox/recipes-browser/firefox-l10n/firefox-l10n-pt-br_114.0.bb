# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "883fe60a4a684ebc4ea4c05e95372ac6"
SRC_URI[sha256sum] = "cc2035801a929b67b97d5185480757eb51fd8063e360a7bd0d2cecea6edda2e4"
