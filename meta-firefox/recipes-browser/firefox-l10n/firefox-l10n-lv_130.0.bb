# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8074f0e2ff51ca043841afa527e27126"
SRC_URI[sha256sum] = "53a327418433e41def86a5e8238e52ed0d07a9c1377057e61563f328daac5b84"
