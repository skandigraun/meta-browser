# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "acaa95e8fa98f05dd8adb6bc5818745b"
SRC_URI[sha256sum] = "78fe66ab7b6751a2d38d76d72658d5cc816d680f793318db4d526e6b701e8141"
