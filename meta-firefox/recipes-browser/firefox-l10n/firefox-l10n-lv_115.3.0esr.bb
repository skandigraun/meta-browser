# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b419fabc9b27411f1bd2f15800c6166"
SRC_URI[sha256sum] = "fde4bd2f8695452ebb1b7c0b7f074fa28784b218d6dc3c96129585265202875f"
