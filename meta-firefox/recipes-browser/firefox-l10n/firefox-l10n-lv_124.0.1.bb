# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7be0b52a79791218c89868e4184a11db"
SRC_URI[sha256sum] = "2ffe04e773c29de19a97ebc4e9f08dc9d39b5f0f7892e316a97ff24add025613"
