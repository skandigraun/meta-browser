# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b2f3c87b1167f23194fe2aa15acb3c1a"
SRC_URI[sha256sum] = "8e49398a9722036b39387c08e8c6fe87f43a5876bd376b89ba356ac420a9292f"
