# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "edc6c90c12dc421590b7eb778e4de59a"
SRC_URI[sha256sum] = "df6acc0e86b2986213eba9983a262d7e5bd1fa50799c0ec889b96d6affc25fe2"
