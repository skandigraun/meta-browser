# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd1607ed922ca5263ba4152703de75df"
SRC_URI[sha256sum] = "64a52dcc1a9c71701fa214cc42a9daf76ae3d5710684980f5ed11f73f48858cb"
