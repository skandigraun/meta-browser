# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28c603188ad872a97b6e12fdf5acc729"
SRC_URI[sha256sum] = "03ea10714a2c3407b93ad3f47947fc36494408016e887b4e14135302bc7ea7ba"
