# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5383b061a090367fcd596e0c137ae946"
SRC_URI[sha256sum] = "0e2f5c6dc86967477067bf6fa7caebc3e46a1c55df155460ac60927566f59999"
