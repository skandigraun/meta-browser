# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2f0d1e4804bb4d50cffb1478df0c291"
SRC_URI[sha256sum] = "d491430f841d960c72a5a59e899e07a99e2614368c1e5968b7190aea865e6394"
