# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14583603e35a7abe2d34c46ec344f86d"
SRC_URI[sha256sum] = "e3700af38c57e896195e569e5c98fa8d472fc4ce736fd0f0fc1a65cfc177c435"
