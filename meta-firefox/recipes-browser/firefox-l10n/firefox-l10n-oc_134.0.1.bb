# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "651edafd601547362ce80315d8f20ce9"
SRC_URI[sha256sum] = "b7cbc717f61c466ce1032fadbc7902cf8113102500b16305d65169eb3a7da8a3"
