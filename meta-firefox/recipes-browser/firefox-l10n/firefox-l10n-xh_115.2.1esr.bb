# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a18d1583337adc77cee0690a63aefd7c"
SRC_URI[sha256sum] = "22cb2ccdea3e38b385e58732bc4f869534f9ac85256dc02337c7b4b0a6f40c27"
