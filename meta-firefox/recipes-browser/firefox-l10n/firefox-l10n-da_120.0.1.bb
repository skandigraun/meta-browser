# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d5c16d92a84c1cc2b85779ddefadead"
SRC_URI[sha256sum] = "35c8067756870f00e948cc94ae77f729e06562a890e0399946f8de1d1469841d"
