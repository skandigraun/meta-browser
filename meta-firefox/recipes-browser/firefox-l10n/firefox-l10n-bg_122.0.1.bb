# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54e1f4f33f954d63d7de49ef032eefba"
SRC_URI[sha256sum] = "3f0b21dbb44b3273692949fd19f6bd8f5ac70c3b91e02908f51f0db223b90a13"
