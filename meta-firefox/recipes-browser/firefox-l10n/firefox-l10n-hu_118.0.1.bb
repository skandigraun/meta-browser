# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fb6e646481ee9a3876015baace6675a2"
SRC_URI[sha256sum] = "21e4e7f4e5a073d40a2d8f8f06d6cd4372f501284926a93fc66521eb79f3521e"
