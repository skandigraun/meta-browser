# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "842989df5a857a51f392c74b98bc4326"
SRC_URI[sha256sum] = "9ff50a04ae57e8f9755af67d25d06cbc82fc1fde98ad2c20e228d92e9d70d9d2"
