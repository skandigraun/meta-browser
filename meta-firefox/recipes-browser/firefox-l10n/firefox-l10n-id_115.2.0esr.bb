# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bd00a401ed6ac83081c09368e26d322"
SRC_URI[sha256sum] = "8f3bfd54f4c55ffc30f190b954e82c1110d82c5b8ebb79c418d2f44e69ac8559"
