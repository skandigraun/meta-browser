# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d97da75d636ad40986a5e3622d263142"
SRC_URI[sha256sum] = "19b9669593fd528e6c999fd4d8193f3e4941b4e242a4686c274908a8e5fcb112"
