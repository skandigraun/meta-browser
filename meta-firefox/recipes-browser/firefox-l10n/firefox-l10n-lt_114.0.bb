# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89fb8cf3aa23714a9b494e70a666b8cf"
SRC_URI[sha256sum] = "23a448de4027b9b2b7d3ad46d3a53411289a2d9b8fdfcbf2b9d9094d0269ff34"
