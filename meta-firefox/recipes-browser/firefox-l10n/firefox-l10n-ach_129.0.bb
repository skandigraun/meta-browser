# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9dc576d6cb1379a81a7d7e187e70a954"
SRC_URI[sha256sum] = "f6dd4dd8a5135a48457a03d137746ba04f7e2af93e60eac8de8846e27473426f"
