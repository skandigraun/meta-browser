# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0fac81b3984d3f786167e61c24fd7459"
SRC_URI[sha256sum] = "81e8d0d7ce474691bd9deb8477ac8ccce95a1cead6fb5ba74a9686e02282f56a"
