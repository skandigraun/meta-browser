# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07272ebbc94d3b28f65babab694a3edc"
SRC_URI[sha256sum] = "f5d513e82a889adab874d63435e7f5c16506e8120bbe52d4aa852d4077058859"
