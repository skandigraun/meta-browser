# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0773fda2e700982509817fdb6e0025b8"
SRC_URI[sha256sum] = "4afe94329cb79112d2c3ace409102b7375a40d7c290dc51e323ee6ed7f13ca32"
