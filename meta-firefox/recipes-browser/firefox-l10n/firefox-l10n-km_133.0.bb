# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9127ee0aca25da1a71b7d92fb7d5a89d"
SRC_URI[sha256sum] = "7deb024d0705827c205074f428b3c03f23316a8de30c6349620799bbd250ec29"
