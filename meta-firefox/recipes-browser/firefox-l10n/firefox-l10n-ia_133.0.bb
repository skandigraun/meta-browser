# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "846a0aa2e5e63c7bb729af778e95b163"
SRC_URI[sha256sum] = "fc0e12fa91df76f7f1e5873db4144790edb96dfa699af5f565d7970203183503"
