# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "719cc8ab06bd8955bd29265588b19339"
SRC_URI[sha256sum] = "858bb634511d76018548506aea6459bc706cf5c2ce5289df9b898c8059b8ff87"
