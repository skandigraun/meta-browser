# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd7b96a977caffec17b0a7e5ff05da7e"
SRC_URI[sha256sum] = "b790fe0284f33f4dafd605f286c44cc3c2a150d294e49795ad6c8316e7f5e59d"
