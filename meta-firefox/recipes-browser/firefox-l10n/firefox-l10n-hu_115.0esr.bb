# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "915890c692e9ba379e4b0322578ebd31"
SRC_URI[sha256sum] = "284a9e948fd1b781a2ffd8eb18b084b5a81098b7eccc646115338b38f8f23712"
