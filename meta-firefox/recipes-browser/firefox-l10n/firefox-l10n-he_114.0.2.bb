# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b5fe18273fdd2d19a0d6a464862a1d7"
SRC_URI[sha256sum] = "626221e9d335cc517ba3512bde153a700bf20fbaf92e2ec74267986835335f74"
