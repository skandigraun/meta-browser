# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb0f6cc57d1af939ccb58d928edbef2a"
SRC_URI[sha256sum] = "55be4775ddd652517e22b6d6b47762eb070dfe016e3f6a8777342cfa8e2c023d"
