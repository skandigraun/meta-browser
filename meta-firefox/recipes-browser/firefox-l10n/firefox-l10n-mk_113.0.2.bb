# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f595e407b978ffbd5b9dab6043170bf"
SRC_URI[sha256sum] = "69e1ddab74f32b49fc21799a66ea8e6d28b912bb84f974b26db85be4416ebbc5"
