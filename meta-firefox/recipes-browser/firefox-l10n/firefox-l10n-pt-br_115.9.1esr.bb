# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7a520eae28c3a8ccb8e3d080c0716c5"
SRC_URI[sha256sum] = "63632f1fdc667f5c7658b5acf2fd5081bbfc91ead67d7e0d45fc4dfc05555923"
