# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e57d113fa81de16202c3a476257999c"
SRC_URI[sha256sum] = "13bd91b58872ff1dfbba3e8deb9c03e270d31095ad967d9fbffd7ee69ba452b9"
