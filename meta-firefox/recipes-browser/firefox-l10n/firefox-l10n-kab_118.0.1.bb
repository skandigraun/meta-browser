# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b34af2a3960f795c0ab51bd2465259f3"
SRC_URI[sha256sum] = "5284a2dc1cbb06424d11531016c518f770c720420d695aa162863b63507c49af"
