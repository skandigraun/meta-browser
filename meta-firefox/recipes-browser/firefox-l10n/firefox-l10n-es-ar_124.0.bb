# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d05b1ff0df6c48e5e89d2fba201891f2"
SRC_URI[sha256sum] = "2779206551e36df0dcbf4b0983cff42a8fa0a97b0e6f1ffbd2e0ac5b3f94edc0"
