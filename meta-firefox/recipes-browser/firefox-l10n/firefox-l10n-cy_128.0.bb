# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9aa3841657f58044f151b3e31d534137"
SRC_URI[sha256sum] = "2db82e532a83c388c08ecdc18537c84f961a1ea467cf23708f58d4b66e4185c2"
