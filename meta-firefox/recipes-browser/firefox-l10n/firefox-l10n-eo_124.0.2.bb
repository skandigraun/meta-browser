# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d733cec107f111fbb8891b00f77ef841"
SRC_URI[sha256sum] = "5c10b0aee439cd79433c08c2418a0b1aeee4dc550c8e5bb95f6b9f1e270128d7"
