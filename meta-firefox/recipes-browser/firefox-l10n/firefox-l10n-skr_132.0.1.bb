# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4987311f25b50e7633f62ba6ed004f9b"
SRC_URI[sha256sum] = "c931ee0bbfc78d305fec850b84ef6846dabeacd14bf055364c71586242f6da7e"
