# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8a8fd134e28134d861e2f37a5951534"
SRC_URI[sha256sum] = "b59976630969436922dcc235f15fd64ba5a941778b06f422f74cfde08e6dc7a1"
