# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12f49b778191432634bd7c1ae08f895e"
SRC_URI[sha256sum] = "0371feecff7418fd314be6c94c6822dd216f7abb9df7e3ae256c1cf889f91088"
