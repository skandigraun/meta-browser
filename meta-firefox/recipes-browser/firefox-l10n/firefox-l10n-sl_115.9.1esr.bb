# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a76d7ef4719bdd7ae8576a7114908f2"
SRC_URI[sha256sum] = "624177466bd24c09602bed25deeb57a43b812f97920f64475c76e57a5a2c54be"
