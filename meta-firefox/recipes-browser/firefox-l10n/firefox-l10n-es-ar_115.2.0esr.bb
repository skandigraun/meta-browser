# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f6ea57322d4195089ff70054a9e64803"
SRC_URI[sha256sum] = "640a1df675388b03c0641191d7ea41c3f8e26ba0c5ff81b032e1496553e8f515"
