# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "93b3988866813d5e2c2bcb8cb0deaf0d"
SRC_URI[sha256sum] = "30a32fa9e0a607d183cccfaecb958c6b1acfa06e31e287484c7c705a8351ffc6"
