# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "006f10226facfa608e458a5526484c1f"
SRC_URI[sha256sum] = "8d5be3ac8b3907e3c41dea522abe9395c346ff86961e83ca3fd3356192d7a7b8"
