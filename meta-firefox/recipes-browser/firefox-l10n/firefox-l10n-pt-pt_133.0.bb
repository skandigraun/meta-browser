# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "993fc3c36eb5c57fdb046990195cd6d6"
SRC_URI[sha256sum] = "382b7a361ab21fa316f8f88a429fcd93b95310e991cad4a762dbb96cccad0cf2"
