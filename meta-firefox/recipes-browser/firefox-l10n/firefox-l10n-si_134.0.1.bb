# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e44cace7ddcb2018a76e279a65815c6"
SRC_URI[sha256sum] = "4b756c991d61188e097ea8744c565fccbc208bfe43c35e82b65285196c0afa5e"
