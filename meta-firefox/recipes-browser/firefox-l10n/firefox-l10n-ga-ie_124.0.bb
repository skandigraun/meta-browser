# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2092ffe0a4672c121a599945f4de9244"
SRC_URI[sha256sum] = "94444b076e63fb7a1a62f7097471de153f00f347796c9f6622d71a0876769174"
