# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b25cf9b1494c407f8c22db786d614b4"
SRC_URI[sha256sum] = "42c75c3aa27f8eae2bc11bb980ab9dcee5e4bec1493d883a6cb93bc06297aa20"
