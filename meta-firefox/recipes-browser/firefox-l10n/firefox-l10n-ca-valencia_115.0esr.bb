# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89045ec57495e0d88ff6c3b6e4077582"
SRC_URI[sha256sum] = "4c06690ffd48b5c3fd8bd9a16b46f4ba29fdb73bade30df08c63055cbf9a54e8"
