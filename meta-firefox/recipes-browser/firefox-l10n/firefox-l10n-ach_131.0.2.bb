# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c82c1076653cee388bdc0a1bfc87ae86"
SRC_URI[sha256sum] = "b62d241526de5321aa31f746b193e20b3f0c733d2594e642365c839c2bc87878"
