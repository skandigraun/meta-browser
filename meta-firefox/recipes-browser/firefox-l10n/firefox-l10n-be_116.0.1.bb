# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "540a5a41b90673428df85f2115652cd0"
SRC_URI[sha256sum] = "97c13e392a4ad08391c7c3ce7eef4e4a477a34d5027a51002db374de31aa0bc5"
