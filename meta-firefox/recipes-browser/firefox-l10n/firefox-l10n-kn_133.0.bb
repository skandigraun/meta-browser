# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bd8be1339933ae8263d9ea4356fed10"
SRC_URI[sha256sum] = "5d1409b980e2ded7369a156b7c0b91ed5efdf66cca0d2872982e2cbdd8a8be26"
