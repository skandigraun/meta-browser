# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b7bcd5c48e3002d92f303cc4dda6f98"
SRC_URI[sha256sum] = "cffbe6cbb3ab4492754c553c25c2bb5a31df1569479548d2b1b2a358d75e5ccf"
