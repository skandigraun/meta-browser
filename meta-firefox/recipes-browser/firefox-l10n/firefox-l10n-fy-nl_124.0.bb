# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41dae6e7eab8ac6c7100e088387fef81"
SRC_URI[sha256sum] = "338aebdd3d86c1a7b815670a91f127c17377941ea0a83efe64e1ad164b3e68b6"
