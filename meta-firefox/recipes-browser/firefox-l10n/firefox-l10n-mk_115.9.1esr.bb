# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9e214431729297e3f8d88369bf43375"
SRC_URI[sha256sum] = "fbe5e3faaab95ae24d516ad51ec324dc78ed88dea7e754b6d7f44c9efbe61e41"
