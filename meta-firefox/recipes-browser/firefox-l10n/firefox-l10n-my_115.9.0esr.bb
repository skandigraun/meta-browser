# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e71a994212c7c38eeefb86ea9b2b8d3"
SRC_URI[sha256sum] = "1411d952a9d295280d95200bdb12e7bcc58ab8624c3c6111e6c5b29d0bffc498"
