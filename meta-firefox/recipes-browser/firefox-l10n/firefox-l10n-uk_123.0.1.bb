# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e6bb8382e01990d085f02df6a6c20a"
SRC_URI[sha256sum] = "edaac5209749a5ea5278654ea82aa5be300ebd09a181ba5489a945086867e21c"
