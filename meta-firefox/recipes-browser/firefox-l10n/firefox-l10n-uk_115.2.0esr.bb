# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2179550cc9351a5a861a43a0f9517e4c"
SRC_URI[sha256sum] = "10f1e8e48d0bc5bdf08f2ec7b50d806be7ae795962c524052ed4acf3450113c8"
