# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4b657340dac3e897b34ba95f613e8d0"
SRC_URI[sha256sum] = "9ccc6f8a75eaa31796605b766a9354b7a3a5ab15a8cb7d69dfc0dad91fb3ef22"
