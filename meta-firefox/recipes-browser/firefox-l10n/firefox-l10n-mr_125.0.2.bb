# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "149572546b69f45548f441da23fb23e3"
SRC_URI[sha256sum] = "75b30a50672a1cb67a3bc3f406a572a6e4aa5b9b8b5068bf0aa4ef981ba7f9e2"
