# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4123eb1242acb1b69d8f8390c113ee01"
SRC_URI[sha256sum] = "1f8d8d7478fce55b601c682d97f682612519318703ba3059bf9b6693d7e863d4"
