# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "333ec33d0d714d44049d3c22203b4ebc"
SRC_URI[sha256sum] = "981894d7ab3e597221e8cf8c0ca8707ef2f5e0f4b68ef199a7cdd5b7d3f77013"
