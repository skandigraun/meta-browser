# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ae534a7ace100592a3d6efbf1fef614"
SRC_URI[sha256sum] = "8818e614c38e716a1c0fc0482b307c261e701b3feb8f989896697b9503235ef7"
