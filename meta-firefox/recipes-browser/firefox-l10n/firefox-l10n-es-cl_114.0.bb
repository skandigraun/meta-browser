# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8db9435809527224722f43c7027409f1"
SRC_URI[sha256sum] = "c7ff4fee557227e6dbf87a1bd12205217710e41028066b0da3ed46adc3df2944"
