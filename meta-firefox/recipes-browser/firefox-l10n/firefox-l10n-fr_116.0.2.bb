# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ceca18d6c91b2894b4632e7ed854c7b2"
SRC_URI[sha256sum] = "a4d836581bad3ab1d1f1ea89c845064f3025c4d7df96ccb42cca85b054b4af6e"
