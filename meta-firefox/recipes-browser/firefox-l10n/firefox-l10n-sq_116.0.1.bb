# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68b82f361b341a1305d0ee1da03c61d"
SRC_URI[sha256sum] = "b2f1e0b9fa7c4c8d095e70781fc7fba4d2e378a2c5b7a97138a336a14b8641a0"
