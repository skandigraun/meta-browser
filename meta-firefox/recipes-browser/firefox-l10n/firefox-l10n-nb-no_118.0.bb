# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3145d790114d16522a25f2afd727541"
SRC_URI[sha256sum] = "1623aa6a1ba7f6bfe6074065e01f58a55fe082d2fcf42700a3567a4af36ec207"
