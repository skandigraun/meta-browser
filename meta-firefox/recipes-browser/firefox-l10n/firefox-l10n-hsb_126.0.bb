# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1268b9f35163286ca9d89cbc7638b83e"
SRC_URI[sha256sum] = "0a76f187061fce832851d7ee25c46545a7f29174b4a8de38968e279ca79becbf"
