# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a9b8236b483b7cb7cb8f21140b5457e"
SRC_URI[sha256sum] = "5348be089c66314a4ece864659894a42c993b02c94246606ae24963acf495e86"
