# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91fc40a8246ce1b695d75b1220df9ee9"
SRC_URI[sha256sum] = "129981bf7628f49fba9522636211405b66fb14159f76c557b93d6d810c672cc2"
