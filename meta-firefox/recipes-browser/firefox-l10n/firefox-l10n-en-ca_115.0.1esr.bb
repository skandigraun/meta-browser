# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11ec50466b610af05e9ff49048da3121"
SRC_URI[sha256sum] = "015b3b8e6cb0201fe24336eeec3df0c42300f9175bef0540d17b39ffc786374f"
