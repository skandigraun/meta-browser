# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4e62a0e48039291728333ea59d186bd"
SRC_URI[sha256sum] = "a80df51d7be99eb5a1f5ee1351f9b8b556fd4e13c35c59b6f035b464f7c57424"
