# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d5b5946e4e16cb732492b4f5b449874"
SRC_URI[sha256sum] = "a9fb9d59d0ed9698b770f278190033fb0a860b2762ac30c5b584c4af75108974"
