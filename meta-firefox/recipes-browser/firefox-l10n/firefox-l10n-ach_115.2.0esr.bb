# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40cdbcc68bc98ca7f25e59793bda9557"
SRC_URI[sha256sum] = "549b70185c4ddf44ee30e760f847d16b9be8d6ed7a2c80fef2141e83a31fcdb7"
