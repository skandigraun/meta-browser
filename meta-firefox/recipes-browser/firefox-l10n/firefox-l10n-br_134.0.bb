# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "567e970375d196248927b7903c0e5a45"
SRC_URI[sha256sum] = "6fa69f3722b81e9a03a3d2319fc6047601dbb31f2fe7996fe02d472d05fbb0c8"
