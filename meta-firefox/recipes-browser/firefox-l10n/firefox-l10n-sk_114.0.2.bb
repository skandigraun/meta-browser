# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66d62a49a2ea1616f67d832e22d48aa7"
SRC_URI[sha256sum] = "fbe2b18eb4a3a9035c2b1bbe74a366018afdf97dd140c86cd446863f3d1257f9"
