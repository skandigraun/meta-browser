# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cae602c36fdea298554d6db362ae36c9"
SRC_URI[sha256sum] = "81b13adf2250144d4a357c8a2561d9a55c6dd3f6d02f073850bd1373181ca4b0"
