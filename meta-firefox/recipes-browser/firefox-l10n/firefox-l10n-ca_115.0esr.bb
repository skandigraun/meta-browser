# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00c4eac6bc9c6f0500795053fbc90f69"
SRC_URI[sha256sum] = "8cbf3229816bcc24b1e02c973dad0e503c1652bb1bf75886a692b08f7a9774de"
