# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7aa2629b6ff267c6291a80f0e93583b"
SRC_URI[sha256sum] = "b5b4fd85e64bc71f733adc62ed261fd7635323214021689292d7c2f0ff8860e9"
