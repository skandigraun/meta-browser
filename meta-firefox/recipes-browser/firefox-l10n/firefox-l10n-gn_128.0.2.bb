# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7bbcc55f411bb9782f97fb3999d67e7f"
SRC_URI[sha256sum] = "f39bf3135183cbb305de743cdf81657a1fb3275bf13d931048cbc2f1dbbab8c5"
