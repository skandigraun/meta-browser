# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b400f9de56a2703bce97a2d928afdcc4"
SRC_URI[sha256sum] = "f30663b04689e58953683384f4a5ae007140895cb1a57ef61dfaa161ef4d9975"
