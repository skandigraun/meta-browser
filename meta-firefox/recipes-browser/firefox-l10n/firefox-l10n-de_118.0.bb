# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aadcc6a25ad002da620e398675b826a0"
SRC_URI[sha256sum] = "3a234c0b678ea7f1068c4f0e6f3f93baa14b06b7a185578ef6bf79c63eaebb13"
