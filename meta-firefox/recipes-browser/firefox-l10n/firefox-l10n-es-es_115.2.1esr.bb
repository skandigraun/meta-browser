# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e952a0f3a44c51313d12e322bedf2973"
SRC_URI[sha256sum] = "3f27e88d69e3e279ebaf768a44b8602a0b339be9f3cdc03113c405cbcda1d469"
