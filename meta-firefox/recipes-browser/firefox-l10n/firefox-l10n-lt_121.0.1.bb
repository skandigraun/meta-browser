# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28cb64f1a460cb2cd10a27a52db589af"
SRC_URI[sha256sum] = "01f66cdb3a187b3f6573ca90c5d41b037cdaaa9f402d722dbdd66bbd2e7139f3"
