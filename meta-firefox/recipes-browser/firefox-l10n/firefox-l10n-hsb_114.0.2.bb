# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6f03cf7bbc7f0e8ce1ed27180d55871"
SRC_URI[sha256sum] = "09603e5eee049f9b5130f98bc4859263061a3bfd2f73a4e726ac39553e3233bd"
