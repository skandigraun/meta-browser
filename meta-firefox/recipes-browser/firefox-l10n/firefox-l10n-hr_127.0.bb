# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2da891c7f1adc486ff1f3b609c37aa8"
SRC_URI[sha256sum] = "157d6400e57ec004b52125e82767d1f402fd87cb8c86ff8e8cd5c4425917c060"
