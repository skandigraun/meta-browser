# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "adc0a715d1cc4ee615010b0d8d177ddd"
SRC_URI[sha256sum] = "d761e8f6ff6654e83efeeb24c6ce52216f894ab4fdc039dd7058f8e39b5042ea"
