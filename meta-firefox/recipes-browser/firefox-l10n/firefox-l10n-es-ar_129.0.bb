# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d9b91651c3a637c830acc1fc8c07873"
SRC_URI[sha256sum] = "9737c8743c635eb168896c0731723460e97af4c887ee63da1ffbdcf8a805a873"
