# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "548414708bd09e3898ee753eba5fba98"
SRC_URI[sha256sum] = "8628860b4b31ced8b3b5ba2d62e27e7ba3d81f9caab2654fa66fefad5b987510"
