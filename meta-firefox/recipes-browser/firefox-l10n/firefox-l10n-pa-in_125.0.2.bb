# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37c00253cc01b6fa0ab0d6bbcbc3aced"
SRC_URI[sha256sum] = "c64db0fd94bd8c41e6981dcece95c15bb88fb1829e2176f7eb7e284e5f283731"
