# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe8dc0f390a01fbef6dfe6050c66f791"
SRC_URI[sha256sum] = "9405fdedec1c7ef9cc73bed5762b50599362fd7966a029598e56441bc7b96cb5"
