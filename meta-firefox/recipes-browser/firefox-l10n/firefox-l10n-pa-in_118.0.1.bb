# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06fef4b0e7f3b2b0ff991e5df8c45c7a"
SRC_URI[sha256sum] = "0108a01540b3710a395c72124395875aebd9c9db96be9aa90a484a69cd2fb5e1"
