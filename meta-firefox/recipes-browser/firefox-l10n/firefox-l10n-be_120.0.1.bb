# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdf3efb1b1ce9b0beffdd8b2fb8ada6b"
SRC_URI[sha256sum] = "d551173b9ef02bb4bd40c20a2cd89f06a5f46f266df9a08ec3cb7ab6223c04a0"
