# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8c6d9d6eb11c41f60d331b26b55f101"
SRC_URI[sha256sum] = "1b0cbbb92e3c382e7f2a604ac444f9f4977c773bcc07010902d3ecefa9358b45"
