# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9498909c06316eaee7b6c46f97f97adb"
SRC_URI[sha256sum] = "f9849a3ae3ef4919f340979b9ff52266d0b4c1c31c9742a5a055d9941decb492"
