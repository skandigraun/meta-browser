# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69e3d169cc81d5bf7e165ca4a3388afd"
SRC_URI[sha256sum] = "e5eb3871ccbe6ad98f0277c3d97adc1deef3a1293be09cccc5f62d7257da7994"
