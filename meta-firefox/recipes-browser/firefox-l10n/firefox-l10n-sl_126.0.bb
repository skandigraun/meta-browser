# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d485c043dfd8938cd97b98582498e988"
SRC_URI[sha256sum] = "8b9e7ddbcc4c57265533eaef341c9602da9edea0aec6be261eb0468ea5b75aa5"
