# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ae75fd21d37c0c11122e7ac3fb161ec"
SRC_URI[sha256sum] = "c2dcc85a63721082bcec383cfc02cbe9f516e9e0fa04910ee8b167fc8569fc4f"
