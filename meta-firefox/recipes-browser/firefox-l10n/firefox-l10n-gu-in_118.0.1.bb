# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "98c9db5fbf238fb063176dc42c746e91"
SRC_URI[sha256sum] = "2cca11037dd8db9a2c7de8d5895ce98914b12076a0677994fced35b926b3c0af"
