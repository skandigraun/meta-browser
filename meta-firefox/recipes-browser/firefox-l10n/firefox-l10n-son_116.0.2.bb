# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a46cf78c3494e766e1e0aadb37c8ae39"
SRC_URI[sha256sum] = "6544cc80062e8a194bc9a0bdcf3e4b00260cfb456c65ee36cf45aa630013698a"
