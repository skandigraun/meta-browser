# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4778eb6fc9693de493c17cff35af212"
SRC_URI[sha256sum] = "8a708cc7944659ad3852aae58dcf67808904e9b0cffe314098c4520703291589"
