# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9e4e88344544a448edc80f136205f5b"
SRC_URI[sha256sum] = "5cdbaccee5668c60f348d1fd1bb1b2ab61cff09b39dbb49ecac37ba0d02414ba"
