# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97d423be27443460ac38d856f8d3f0b4"
SRC_URI[sha256sum] = "a849ab64e6f707454ea729b9a56edbffca9fcbd87331bf28808b61539866fd2f"
