# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60fc95c185988b2d210ea010de16a7d9"
SRC_URI[sha256sum] = "215f59492a65075057dbdbcb42cca39ea7148f36503d4343bb1a6173e14a3b90"
