# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7ab354ae88cce87fb7857074fae7fd3"
SRC_URI[sha256sum] = "345863e68acae08eebc08b5cbb499b6d4e1f49ffe973f1c5166d1156a004d420"
