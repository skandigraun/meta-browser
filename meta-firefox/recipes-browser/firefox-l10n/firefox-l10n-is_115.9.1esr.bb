# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdcbcfdbf42ede2232e57ed1a87b034b"
SRC_URI[sha256sum] = "8f6453eec188fec1140c1b1921d10586f75c0c65191c24d71983d3b9434a41e6"
