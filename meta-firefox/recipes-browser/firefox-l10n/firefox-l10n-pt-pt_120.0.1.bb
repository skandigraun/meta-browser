# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e29f814a95e1b91ebc61193818dc851b"
SRC_URI[sha256sum] = "a923f02bf2b7f5e7b9fcb7c6fb7165c7e2208cb9e4c9a32ff12b1a96975b602c"
