# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "847b521e78f41c59238636edf8de0430"
SRC_URI[sha256sum] = "a699a7dca126c691ba437ef11560ae76cb22dc1ab3499b4288a777ab56ea6afe"
