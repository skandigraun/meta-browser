# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e24529727f05a5eb64ec68bd04e445ca"
SRC_URI[sha256sum] = "a0246bf4c4f228c00319d1802934f8e68136024951b43524fb6f345253d9c466"
