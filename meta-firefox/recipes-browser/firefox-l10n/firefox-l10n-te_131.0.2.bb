# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd83b088636371d86f2ce5a51723ea1b"
SRC_URI[sha256sum] = "416e49048f8ec1500e923bbd3ba7414e7592d3cef15881ae11b75eeae5e16141"
