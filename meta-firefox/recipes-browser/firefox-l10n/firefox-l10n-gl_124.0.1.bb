# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f6230f44ae61137bed5f99af7f7d55c"
SRC_URI[sha256sum] = "bfbbf58581098317e28c9870e44939bceed69038d76896553d941770d2c0243e"
