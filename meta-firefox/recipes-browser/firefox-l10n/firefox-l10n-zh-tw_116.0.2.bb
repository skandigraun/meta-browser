# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "254db4c2055a0abdc7ca02967d3de690"
SRC_URI[sha256sum] = "77ef88cb6c6499e98b3a220a66d737f0e1c0cf16bcf91bb9aa37accf75e2e1a4"
