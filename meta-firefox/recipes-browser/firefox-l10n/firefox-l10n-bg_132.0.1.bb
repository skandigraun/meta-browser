# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7be177537a9fb69f5d12017f7e367968"
SRC_URI[sha256sum] = "b2dbee9213dde1fd930ed4141f689d85d2f6a6725e443298e975371802f0097c"
