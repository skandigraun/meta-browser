# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1f62bdc7236e6ac740485f80ad2a287"
SRC_URI[sha256sum] = "ee55a1878a6c6fe8a4e1c303900bca0d9e1835fe688671b6743ae9bde00af568"
