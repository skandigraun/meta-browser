# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f17e203702e869b41c62064f4a625f99"
SRC_URI[sha256sum] = "d341c16b3156f1d24f3f73b004c642db486b7084dd55787f1764ed03f3277683"
