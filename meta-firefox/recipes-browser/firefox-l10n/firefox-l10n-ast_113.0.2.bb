# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca27c8994ce67a738c4783bcd82c1fd8"
SRC_URI[sha256sum] = "761127e2ef85708302fef1532f73b6c9cb9814ed2ae305aa6f63e6d41a855756"
