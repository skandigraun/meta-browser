# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6fb28ac44083f90e27e08d055907a05"
SRC_URI[sha256sum] = "692f774bc3deda4e629e97afce6cf644f9fe0d8daaf3ff8dd58a34ea9ba129bd"
