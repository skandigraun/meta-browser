# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72aa913422ff7670cf1da6d58d7b9e53"
SRC_URI[sha256sum] = "8a4c8cc64e7600a4146aabc0b7939eb66317ab07e803de8737a890006ee2a4b4"
