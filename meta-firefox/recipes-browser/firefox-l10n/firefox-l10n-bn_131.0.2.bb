# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9243af8909bb70b441bb548bc8cd5261"
SRC_URI[sha256sum] = "6153e33f547d97d757b6c3741fff661a8033a9b6ec895bfe72fe4965fdd520cf"
