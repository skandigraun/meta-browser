# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10394a3c25880fdd60954b364cfdbf57"
SRC_URI[sha256sum] = "521af6e7da9a79ad7fee6ef5116d92f25eabd495cb058e0c95f302d34d0bbbfc"
