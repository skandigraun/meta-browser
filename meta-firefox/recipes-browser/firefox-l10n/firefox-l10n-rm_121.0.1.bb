# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e10d8cd3b0e6ba5df799de82cb1f403"
SRC_URI[sha256sum] = "2744fa7fb4d9d8c1fe1458dd40ebbb99f0fde89786c13f24837f0decbf2138cf"
