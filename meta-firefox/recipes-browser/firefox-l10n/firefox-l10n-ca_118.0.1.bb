# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c455d1ddca19006b1ebf0e08575bf1"
SRC_URI[sha256sum] = "6c5dbed0bbe89954c3426b0c9175fe47210c27248da997bc29c896e594cf1454"
