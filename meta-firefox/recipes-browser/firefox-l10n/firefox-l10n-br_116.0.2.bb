# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13747042f332bbc85c8e8c90b7918947"
SRC_URI[sha256sum] = "0a97f08f378a81bf62b123c1370b2fb4ea42f87dc6b366b07d579379d123229f"
