# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b67a848fef39be5df2a9e876165a583"
SRC_URI[sha256sum] = "775d07614a086c918944cb0b0d9f28ac87313aa46190c5c24c33158a6ec2923d"
