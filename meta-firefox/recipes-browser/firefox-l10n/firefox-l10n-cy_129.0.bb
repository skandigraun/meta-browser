# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7867a4b54c5c933e1661a81a5ff98667"
SRC_URI[sha256sum] = "d309d8f1bcd1efa97ec7291ab3ae29324b70b782859a5ee52bcd97d42bce05f4"
