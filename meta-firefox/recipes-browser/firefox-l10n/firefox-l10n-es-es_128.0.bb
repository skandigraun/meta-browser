# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69ba136dbd8aaeade6d8a01bd8ba4559"
SRC_URI[sha256sum] = "11d67042cfab71ec1d965567e41db10d9113c12f69a0a0dc7fb2d3e0cba2680d"
