# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76463ba9bfa39e19dd7e441dfb50df64"
SRC_URI[sha256sum] = "d2a5bd13272e42bb2c928149115ca3627e95ad227273729aa46d5e797f6f0549"
