# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "282e2f332ea827ebb199b7a925e70213"
SRC_URI[sha256sum] = "72de57f652d36b455e8a8812fc64e37011443fa81ce68fd1435f46c83528aa7f"
