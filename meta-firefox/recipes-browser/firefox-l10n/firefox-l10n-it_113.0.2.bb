# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c0aa98980125961f130c2091b76384b"
SRC_URI[sha256sum] = "4f7314959ceac3c134bc12e13e4d7481258e22f91f1ac1757c444920fd80ad69"
