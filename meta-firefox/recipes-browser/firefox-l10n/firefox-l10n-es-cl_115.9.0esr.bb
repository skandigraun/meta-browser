# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce07e185397a3431a14890a25d29f502"
SRC_URI[sha256sum] = "44151b2a1cf245c6eac12abb2e29caa5cc40c140c95be009f31e9e4b5f69b9f3"
