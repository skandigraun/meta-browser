# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da6067953cb863faa50735e1ed306de1"
SRC_URI[sha256sum] = "a8011d7f2581851257526dde06bef1970a9bd32f9ef95f7e4721965e7a97017a"
