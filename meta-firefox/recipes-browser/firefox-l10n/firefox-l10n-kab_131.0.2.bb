# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55350f59f792f0ba9fab2365c2b2da3f"
SRC_URI[sha256sum] = "9fef35f6bbcd98a5eca68d779f97d3be5c024b871ea9bec306f3a22744e92203"
