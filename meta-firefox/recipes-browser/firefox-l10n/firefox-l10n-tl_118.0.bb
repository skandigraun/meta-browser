# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33e8e609b446706032b6c417febb325c"
SRC_URI[sha256sum] = "007aa435f0ba0792ddeeae9acd822b2e00be84e58b9439fd552408e300454fe0"
