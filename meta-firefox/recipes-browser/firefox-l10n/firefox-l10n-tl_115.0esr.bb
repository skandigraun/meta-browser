# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ae9d91d06edcdc84eebbf8289aa58b6"
SRC_URI[sha256sum] = "98224ea792495e9e580ebd58e5e36806b1aaca01306e55f5ab22b635c801a8a1"
