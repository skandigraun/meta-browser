# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d39b69722d13be9b99ce2114fe867869"
SRC_URI[sha256sum] = "b0a69aab94e73520fffaf2a42dde0a36f712ca9e749f6ffd663bed01324f4fc1"
