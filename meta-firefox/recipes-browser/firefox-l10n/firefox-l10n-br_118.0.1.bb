# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "336a67cd28c4b2012dc40128ea8aee7e"
SRC_URI[sha256sum] = "e64f83706b679bf700523c072c501f3517f87a3066638954cbcea5d7d2c1bb35"
