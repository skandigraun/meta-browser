# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c3b02d358308f5df533902ac13d63c73"
SRC_URI[sha256sum] = "e7e6c055a9ba683bea457777179ae4bd9a02d23a0d7cd8e1c5f694a0e2a30f70"
