# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28b30e62f37c81aec5c848b679164ea2"
SRC_URI[sha256sum] = "43cb3851a8a01dcd9fee034bd1308b8c36a715adba6fad13050a1187882f8dc1"
