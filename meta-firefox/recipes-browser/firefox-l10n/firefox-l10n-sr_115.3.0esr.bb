# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16384143cb7a99c89b7905a92ee850f0"
SRC_URI[sha256sum] = "4e1a1557f937e4bc076d37e2e108c7d79d7cdf47f747cb6fb5baf49834a42ae1"
