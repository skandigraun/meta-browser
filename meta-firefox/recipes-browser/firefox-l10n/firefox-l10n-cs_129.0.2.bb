# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1832ba923963bb9dd0c6decd49d7fac0"
SRC_URI[sha256sum] = "665a4d0c9c6e728780a39fec3c9a61a20f2fa799695f7dc7b94e41cef803ffca"
