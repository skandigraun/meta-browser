# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "614a4b2a572b6fc4479c0f78c3b021c4"
SRC_URI[sha256sum] = "b5fe3cd02e930399d0391036bd0f75093f9b10312d3af4f270009fe6a9188dc0"
