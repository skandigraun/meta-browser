# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6373cf39e89d101cdde562598a6d206d"
SRC_URI[sha256sum] = "027dab44714bc20135cf87a031a3a98ce5d15b8d237b3a083186473a9bdc0df4"
