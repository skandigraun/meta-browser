# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e50304dd5d63b325a47bc3b94cfe079"
SRC_URI[sha256sum] = "ed75e9db941684205ecb283e5e95d5b1f56518613f2174f503dcd83ae6629574"
