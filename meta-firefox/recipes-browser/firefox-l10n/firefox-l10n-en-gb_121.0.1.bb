# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5521278ea44d3c2fc7d420a5c94c814f"
SRC_URI[sha256sum] = "369ef13e3be9eab11fc9f34d9b97e69c4ba165108f90b86e6b8fe7e1eeea7a5e"
