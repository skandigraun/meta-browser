# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2418a6a991720c87576f38dbdb972ac0"
SRC_URI[sha256sum] = "facf853ada4beeb4e8524544e5baf2fe129808dd3f8241a81426a3c08680c1c4"
