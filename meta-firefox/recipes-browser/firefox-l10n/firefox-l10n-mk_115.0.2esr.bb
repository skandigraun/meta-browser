# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d598b6750f89c741df757570d1da68ed"
SRC_URI[sha256sum] = "d7d3babf5fa6c9e52337ca9e3dd0eca3ed24ed7ee22acfd8135e2d9d76fe9565"
