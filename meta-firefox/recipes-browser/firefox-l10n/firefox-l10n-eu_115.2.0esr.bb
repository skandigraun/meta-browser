# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52f7cd8a2f9e2beb343a9e4750df4699"
SRC_URI[sha256sum] = "7382a551413f9f68736b189dbccf73c6e12229aa89cf4c40fd6c308604dd830c"
