# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1571d6687ce3fea283223d412a7ca1e"
SRC_URI[sha256sum] = "a349bcd732074b8dd12e72ce88a318d7359d0e5e432126df8e5510f8990e8564"
