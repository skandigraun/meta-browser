# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "339fcb2b70fdcdd198f262eb0d756024"
SRC_URI[sha256sum] = "32230d67cfba8b5bc601db11eb98054d29ed32bce67fa4d7e643d744a90a5ee8"
