# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8fdfa4a888a6bc283be629138b5208f"
SRC_URI[sha256sum] = "f2814cd6cd1e13dc7c84f79056ebe0b2badfb22ef7aecbe592c8009c933fcae9"
