# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a86a03dad983f0c872033ce2aad7dfe"
SRC_URI[sha256sum] = "7007bcd84765416786ce7092eb0c06c711a7503b3914c279aeb29819c0da44ce"
