# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84e4d0ede62fbd2f74c84052a4991a15"
SRC_URI[sha256sum] = "56264cf1d3c539339132d842cdb53de1485cdab86bd1a51844bea3d0450a5372"
