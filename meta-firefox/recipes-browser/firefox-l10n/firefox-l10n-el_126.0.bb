# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3d951570c73c87a799dc972adc27843"
SRC_URI[sha256sum] = "6368d829c580e6a3ab74bd6e23363af45331d8000e363e79e112dae664265b64"
