# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07a371aeb69109b1a4fdb22de8466323"
SRC_URI[sha256sum] = "17b9eb2dd1ec821f3c40450d62b80e5e240a636e056c0deca21dff92a4794f64"
