# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea73f41f04cbe5de9c6f3b3beff73611"
SRC_URI[sha256sum] = "4a4b945c21a80f8034b0c6680663cca544ffebb6d8ebb39630fd4f4b65b18e8f"
