# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ea92ef3c7f7fc4910b6e2b12287a9ff"
SRC_URI[sha256sum] = "6f627f254b30b570e60475747d21d8d8649eeb0411b8581f30bc7f5ebd918c87"
