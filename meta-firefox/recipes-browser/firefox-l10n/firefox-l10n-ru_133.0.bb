# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f37bc49751d8efe18d95f8a5fff8591"
SRC_URI[sha256sum] = "c7cf2da2220bf4e5799941a9ce0683f50e0c4b9946f52eaa68a6f7aea459d93d"
