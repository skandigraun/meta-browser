# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9ef78c4b8c93d30f05430d22242c20d"
SRC_URI[sha256sum] = "028914087b0eab5c69575f110507df0fdb5f2421cd047d8f556fbdf14f189377"
