# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "afe6e1c4dd382f82781265011f02f34d"
SRC_URI[sha256sum] = "9c3bdf1a610b0a2303a37cbaeaf8da76f4f27e8a0c2597be7f44085c71a9de29"
