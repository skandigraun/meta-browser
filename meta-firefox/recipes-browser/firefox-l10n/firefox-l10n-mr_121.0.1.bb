# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e80e55fd2fc01a4d5b95e9ae3614f83"
SRC_URI[sha256sum] = "c0b9ec62104ffa5ec2984e8606779c373915ffc5ff53db24fc1baa8979279de9"
