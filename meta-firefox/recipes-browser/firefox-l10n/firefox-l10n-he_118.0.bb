# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "522e30846fc4c6c64e19d90e8421ac4d"
SRC_URI[sha256sum] = "b1ca217be67f34186774722771820337960352c4015e0c2e7e023cd6f2110c55"
