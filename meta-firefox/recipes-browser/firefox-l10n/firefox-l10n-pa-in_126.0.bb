# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a53162e4cb16ffe9d0e961c423465f2"
SRC_URI[sha256sum] = "a97687b2ccd1bfeb3bf3e94480fe163f31aff019c2ac579d62372b4ca6a1218d"
