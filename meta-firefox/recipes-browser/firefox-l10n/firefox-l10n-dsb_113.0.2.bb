# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "be471c159662c6ffa8385112f2869a27"
SRC_URI[sha256sum] = "bf8576e005ad61463a90f312b163d5f2d43cd8ba2dc197e692de4923989612fe"
