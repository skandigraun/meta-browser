# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f49c00e64d7ccaa0df7254b16e8ef2d6"
SRC_URI[sha256sum] = "d34e95809d7217c2132e7d0293c945154d5831e198ae19752f842f7628363103"
