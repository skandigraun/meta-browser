# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce3d56bb61d2fafacee28de2292d4e8"
SRC_URI[sha256sum] = "3371491a0dab91eb4cf7c81917877b26d7d3324dfd77d560c851b3d4e9d20ea7"
