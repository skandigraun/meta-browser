# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "288712ed72bd796adccf22a75f746a90"
SRC_URI[sha256sum] = "d7b3ad53d853f514b86e64f09370113aae5cad09fa1ed7042de200525be3ab57"
