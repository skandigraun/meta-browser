# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1aeda9c5829c8b161897b3defd9970e"
SRC_URI[sha256sum] = "aa5f7dca8b894d9d558f95e72144d2e322f140676e8f0f37f506389bfb1d0329"
