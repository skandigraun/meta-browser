# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9dfcd194e83fd1760bd117e427a4dbb"
SRC_URI[sha256sum] = "3949ccca49d7563ac5e177f80682ef3447c97fbb232c46af27e708ad499d0ea2"
