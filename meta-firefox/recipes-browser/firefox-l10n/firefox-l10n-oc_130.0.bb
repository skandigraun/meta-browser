# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f126ef08c94b0e870d4aee7588fdaafc"
SRC_URI[sha256sum] = "2c4a54f8ca732113d1a6859e8d7f5ed7524b812634ab03e9fbefbeef6d1f7c22"
