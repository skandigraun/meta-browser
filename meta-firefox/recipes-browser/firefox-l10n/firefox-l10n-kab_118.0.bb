# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e229a5a1e20f26cac07b1adfca51780"
SRC_URI[sha256sum] = "7dc3eb8b43893f26581f3f6f701921088326f00fe1a9083385f349eb2b909cc1"
