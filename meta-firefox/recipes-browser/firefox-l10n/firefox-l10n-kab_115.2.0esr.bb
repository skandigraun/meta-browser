# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c05f9b3392ab0cbc9b8d193498eb81db"
SRC_URI[sha256sum] = "95268f1d8fc5f89a569f380b6452331fa78938c2cb6f9b8d87a0944a7ef3b150"
