# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c30daede78740e1eb45dadf2523b51b0"
SRC_URI[sha256sum] = "df541b8ca75ad1a2b362b86f4380b9b321dc130ec22b0be353d85ea96bbcc4c1"
