# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d8096403f602de80966e2d2eea1447b"
SRC_URI[sha256sum] = "bdb5d648e591c18efad7e3bc353ff98bab3135d70a08a36a28fe1c36280ae2fe"
