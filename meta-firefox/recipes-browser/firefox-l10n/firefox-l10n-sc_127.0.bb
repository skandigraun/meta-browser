# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c31471574e70fc0e5dbfca9a20b472b"
SRC_URI[sha256sum] = "58c7987ae3db9711c27c4a2b34cb62c3f87e216a4da5fec83d959b19125db411"
