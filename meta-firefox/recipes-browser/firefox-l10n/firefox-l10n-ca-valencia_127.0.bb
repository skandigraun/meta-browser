# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "968f02977b086cf13d5f3efab49e673f"
SRC_URI[sha256sum] = "e15f6faf1cdd9753e3712dda8b2d157f888c793ac4925f715cd04d41f04a4b38"
