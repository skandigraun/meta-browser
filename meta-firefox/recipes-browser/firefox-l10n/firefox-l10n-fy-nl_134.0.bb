# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3be523995a6fa2f5fd26bab6f78d847e"
SRC_URI[sha256sum] = "2309306067e64c6d10faee5972fc8b17443f1d2abba66c391c73ec46b8d17019"
