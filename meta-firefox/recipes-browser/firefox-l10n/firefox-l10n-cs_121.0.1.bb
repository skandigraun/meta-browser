# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f4c8008a4d3dfc83baab1552f0b177"
SRC_URI[sha256sum] = "c309fcfaf9a0150d42c7ac1f3f0d5c1fc3405e42c880ddb6cc0db87c790e5eff"
