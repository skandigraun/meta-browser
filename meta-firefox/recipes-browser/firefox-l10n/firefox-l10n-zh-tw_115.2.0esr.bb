# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b87b80b32330e536d1292473ee7f654"
SRC_URI[sha256sum] = "8df8f63f04f46b5ca85caa539626f9020fe2cb95394a69b9c6dcaa8f44d1b601"
