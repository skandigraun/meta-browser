# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9a878b573337e739af9bee86465bedd"
SRC_URI[sha256sum] = "5b49286e6dfb6033781d3afeb58ce65918728e7b78393daeaa47aa0eed2c5211"
