# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7904ead36f731b4ea746608adf5e769"
SRC_URI[sha256sum] = "2b621962df46a18ed9b2b261934addc857ff8334ea5914549c9d1343a4d4b8b4"
