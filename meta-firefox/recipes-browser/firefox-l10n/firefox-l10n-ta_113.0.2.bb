# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3537bc62bddb5880ab2876717c68cbd1"
SRC_URI[sha256sum] = "be2a91074a52709548f7f386af67694a2c7d669b8e8ac6a2f399ce32f218d333"
