# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ef48aceea752a2e11061c7897e4d735"
SRC_URI[sha256sum] = "6da40c5b95eb760ab717060bacc0efd7f81abf47e09a49ec97929c35adfe35a3"
