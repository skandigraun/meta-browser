# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2696d7c9e20ea2526ef4599d1b9bd5ae"
SRC_URI[sha256sum] = "1b1deb0cc4b91fa27eb790780a95d8f8198881da62f2147d45c9f26f7d5e8e6b"
