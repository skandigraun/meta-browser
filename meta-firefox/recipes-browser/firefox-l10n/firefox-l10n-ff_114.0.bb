# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "373cdeec807b3c767168355a81c63027"
SRC_URI[sha256sum] = "ed68f1678df1cedc204c2ebc6363f5ccc82562f684f45455169ffce3a94860ab"
