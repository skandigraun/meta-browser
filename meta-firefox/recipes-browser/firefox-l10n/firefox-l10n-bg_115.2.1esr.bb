# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf771cb907e2ba6c98292aa1ec4f4d85"
SRC_URI[sha256sum] = "0500328100ba51bc56ca06ef22615b5b440971b52d0b09e37985fbebd66adf78"
