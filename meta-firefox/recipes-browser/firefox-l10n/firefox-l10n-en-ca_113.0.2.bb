# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32b2d66aa80d67bf2982c3c4945fa905"
SRC_URI[sha256sum] = "9da26ac6111759260483007c25a72d84b464454f94be2be23eaba64fefdd6cf5"
