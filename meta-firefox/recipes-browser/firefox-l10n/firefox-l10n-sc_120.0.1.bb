# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50c83dbd3751c8702b4008b698e3d684"
SRC_URI[sha256sum] = "fab88e751626060024616435079f042f02ef223749880308968738631a8ce3ec"
