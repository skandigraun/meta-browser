# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58ef44d6347b2d42cb72b08c56eb0aee"
SRC_URI[sha256sum] = "b379bde9cdcdef24c8aeda5a5402410d942aac8e5ebfa8176ae75e24cba8f0b7"
