# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08b2f2f3aad0be431f11ed3bf224e7e0"
SRC_URI[sha256sum] = "90c5865fc2d4cea052bdebb4077290192901b3cc9828fb59560fdc01a9ec6f89"
