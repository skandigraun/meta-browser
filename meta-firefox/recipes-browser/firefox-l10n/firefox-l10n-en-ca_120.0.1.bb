# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcac5d389d724678dfcb9be64fb47ddc"
SRC_URI[sha256sum] = "1be45437a4b4a5bb211ad96505a4f1c942ed0fc4752154cc5f23fb49bc28884b"
