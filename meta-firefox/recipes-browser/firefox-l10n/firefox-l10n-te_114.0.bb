# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13245c02efb9cf9ac57b63191d22c370"
SRC_URI[sha256sum] = "6722b217cd12f3a6502f14865fbf02bae8dceeb98f7a593840a88d57829cbbed"
