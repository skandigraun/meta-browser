# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fb28ac1d14771335796efc0c2b0693e"
SRC_URI[sha256sum] = "3313b51524df42782926e8dc82d260e59c97e662abafbcf6edb531ee8e0c39e6"
