# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db96e973c351337aebca4abbba07065b"
SRC_URI[sha256sum] = "230391b9e6444ada3251d41d66e1110a5a37d87edaa48754d691d4a2f7d4351c"
