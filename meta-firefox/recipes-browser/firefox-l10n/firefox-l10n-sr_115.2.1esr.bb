# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac9f97392341a9607db827fcd48cebb5"
SRC_URI[sha256sum] = "b93d37fe4395fe2a805731b5f8340c227e08c4daafc86b6d182fee7a46538194"
