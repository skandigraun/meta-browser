# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b43c8d3fc13870e2786a2f0e7c10ad1b"
SRC_URI[sha256sum] = "5bcdb90941b9c7eaa62d57614a35e80bcd4317136699f8780df156f191d458a9"
