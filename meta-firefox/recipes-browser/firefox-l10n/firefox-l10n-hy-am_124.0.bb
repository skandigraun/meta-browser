# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb48699a16270baebed606733bb9bbab"
SRC_URI[sha256sum] = "a8833563948bf7fd610896d6372ae1581e924f324bd39703c0d64efec4e8e6f0"
