# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c94e9287bbc9cb85acccfc47340353f"
SRC_URI[sha256sum] = "a82ade1a7dd33a8fc385bccad57d375ff189da822532c4229ba9dfdfd5031aee"
