# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c2d5b881c75576ced9eec4b2132d6c5"
SRC_URI[sha256sum] = "762f1ada54bfa614aa1ca1738db8baf44755b518adb71024512b349a74fc253b"
