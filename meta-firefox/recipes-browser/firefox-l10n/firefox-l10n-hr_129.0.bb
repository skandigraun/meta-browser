# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9054f8b2e7aff2180be54254cbe9559d"
SRC_URI[sha256sum] = "4acbeac471802d6033e62cc08b592c1444758df25cd3e3fe2379f05ad787d03f"
