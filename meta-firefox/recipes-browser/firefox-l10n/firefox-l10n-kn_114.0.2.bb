# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1eacf71d80a503b0b8949069f4bd87d7"
SRC_URI[sha256sum] = "ea087566d7c2815452166744c643f7cf26f609e0f2f4c9160ce7c0d716ba52f4"
