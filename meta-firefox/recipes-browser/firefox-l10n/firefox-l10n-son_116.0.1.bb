# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5487609122f4cb730530f1034bcaffb9"
SRC_URI[sha256sum] = "ebdd8bfbf58bb4f658e0f8f2b1bcb3389f3ab0bf502e0fc112d729e07d2c6ef0"
