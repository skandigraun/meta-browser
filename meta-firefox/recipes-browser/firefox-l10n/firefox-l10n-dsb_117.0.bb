# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a2afb8d20f0b85543022351aebc86ee"
SRC_URI[sha256sum] = "984f5e5d55c57e81002aba9355f08ac2b55f1c270dc4f674cd035222a0b24ddd"
