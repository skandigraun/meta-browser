# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "215f0beabddbd538ff4a1a6789260750"
SRC_URI[sha256sum] = "975e4448d87a5413b0702a8985d8ac4b7b7f2ed53f8d33b192afed79f7bca9b1"
