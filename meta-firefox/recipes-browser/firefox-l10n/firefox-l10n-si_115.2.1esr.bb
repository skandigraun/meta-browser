# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f58a420bf3e339a0cd1b885e6888b129"
SRC_URI[sha256sum] = "c6f8644447ee1338bd4cc7a753e7ad5cfa9d84a18b734ae7cdb20ee2a159d6c0"
