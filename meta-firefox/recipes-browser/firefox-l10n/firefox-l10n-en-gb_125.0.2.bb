# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6a688b7cab94adebe69ac999b360c0e"
SRC_URI[sha256sum] = "8454db05dd1e856b5fa81d7d5283a2a2d3e47bbf828e30caa054c03fbf48f55f"
