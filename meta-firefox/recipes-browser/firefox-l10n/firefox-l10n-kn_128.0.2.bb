# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a029d3a6bc56f8397b70f1ca471da7b"
SRC_URI[sha256sum] = "58cbefc33199faf420f07093e48a67030831bd63863b7b04b8301c2ab04d139f"
