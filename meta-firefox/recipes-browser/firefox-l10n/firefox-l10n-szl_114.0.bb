# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4affd05bdfa541d3d2144fead6d75cd0"
SRC_URI[sha256sum] = "40cbe2372eb4becd098267cdf420bea8a379cb18f13fac0b09e3badaf7a6c2bd"
