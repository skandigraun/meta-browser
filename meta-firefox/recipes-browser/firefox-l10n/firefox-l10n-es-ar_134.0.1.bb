# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd0362be57d8487bb965b2a55b2dc75f"
SRC_URI[sha256sum] = "da466cc2736f240cc2dd3a94cabc90d846a732fadf16a2859f39e2fa56ca9650"
