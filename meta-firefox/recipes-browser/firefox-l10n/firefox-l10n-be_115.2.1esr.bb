# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cc9d3d673a4e73a79ceed33472edd45"
SRC_URI[sha256sum] = "43aaa12c8c8f9ebc3384312eeb27fad8b577328f4c87994f11121028761d1263"
