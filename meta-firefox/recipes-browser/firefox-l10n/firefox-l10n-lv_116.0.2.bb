# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "763075cc7bee11b59f6880b1ea1c7019"
SRC_URI[sha256sum] = "e16adf6ba370df8e0fdb9a879b53dc86cb13e58681b19f4266d55dcc245f6e9f"
