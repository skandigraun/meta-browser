# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df5d55f0ee153f92c29622575539f6d3"
SRC_URI[sha256sum] = "6961f32fad904d17d6a6c9e29e85d504600614090f03cfac8a4ceda14244f9bb"
