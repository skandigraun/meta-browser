# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46cb0f463f943ffe98a9132b1c65c43c"
SRC_URI[sha256sum] = "a1b8d93d1e543198a8343f483b11833d8385b4c38d6fa033b9c576d166211d24"
