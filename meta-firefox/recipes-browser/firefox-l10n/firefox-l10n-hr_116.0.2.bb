# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99dc40c1c03bcc65cdf71e5fcca404b4"
SRC_URI[sha256sum] = "1303d31e2fec82a01f5a0d5fd8d83abdc58ee9186d0b6bd3679b49e5272e31ef"
