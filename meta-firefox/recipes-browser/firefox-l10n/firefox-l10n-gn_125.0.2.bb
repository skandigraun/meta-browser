# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1e8bf36bccc19db6254aabb5e052df3a"
SRC_URI[sha256sum] = "2390f11bbb9a1050786efe5b10fc14eee782a422c84a53922af7eef722206073"
