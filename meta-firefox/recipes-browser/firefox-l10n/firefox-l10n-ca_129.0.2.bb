# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11e66508288e4f4bf0047a46832c6eef"
SRC_URI[sha256sum] = "6e6e35aee62f828211d2ef22ba57f72b3844738304516f694cff3fe5d77dd152"
