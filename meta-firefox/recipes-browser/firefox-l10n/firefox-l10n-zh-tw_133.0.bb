# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac3bc4a94351af5876c618c2b099bbd"
SRC_URI[sha256sum] = "606bb5da5ee4b4a35f191dbd5c63727fc6fa39108c22362ea12f9ec646e7445b"
