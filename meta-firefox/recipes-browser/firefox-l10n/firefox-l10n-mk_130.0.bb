# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3aee5e2a18c0eb09fa8db45ae2869129"
SRC_URI[sha256sum] = "686a4c851c5f30b2a8d930e9d2a98b6d8c78c865e313add24d69d1fe165939d3"
