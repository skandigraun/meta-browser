# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2b34c7a58374d331500f504405706ee"
SRC_URI[sha256sum] = "3d589e809de8f85808f5b33d01916bb8360f665ecbcf2de63fe35e2a7c84da53"
