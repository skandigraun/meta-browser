# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7e9da0d6ffb745c863ec846d3da8e33c"
SRC_URI[sha256sum] = "0382aa72a4056340ced15e9cfd3b3a906c059150dc81ebc0b8c79d3647210d65"
