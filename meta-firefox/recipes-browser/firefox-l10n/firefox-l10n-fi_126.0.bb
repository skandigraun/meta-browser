# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb74a01163f203ebcb4d1308267aceb3"
SRC_URI[sha256sum] = "200b549a2ad1113ee03192c439172147ca10f190fa0690455ebf9a6aff71ea8e"
