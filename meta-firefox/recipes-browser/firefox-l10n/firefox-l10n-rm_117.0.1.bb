# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66afb7b194556b6a3a2712da93a42e3e"
SRC_URI[sha256sum] = "66a1166d664d4f2777a6d72ac8922caf5640daae5a2912a90ee8fcbffc0dbc53"
