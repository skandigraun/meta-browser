# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06fb4b649a5b16d3a18b77852272aca5"
SRC_URI[sha256sum] = "1fa1d3b83ea54f1143c61462399aa36f4c18b5316db95a18d795c65d90839edb"
