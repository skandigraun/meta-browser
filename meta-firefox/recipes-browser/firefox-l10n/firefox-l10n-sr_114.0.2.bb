# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a33625e25801559046c4b25a4565f0a"
SRC_URI[sha256sum] = "6335912f8837909aaa632ae74fe59778d3c4c3aaaf0f08f7eea152fd575917db"
