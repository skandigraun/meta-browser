# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5227d06714c25ab35a21ac814f31d24d"
SRC_URI[sha256sum] = "9e766cfa36e890b9a0420b61f0288e16e2ac08508853e2f3ca074439793886c2"
