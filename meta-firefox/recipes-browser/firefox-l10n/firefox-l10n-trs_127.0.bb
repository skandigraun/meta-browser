# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7591532fde508006b248fec227a0821d"
SRC_URI[sha256sum] = "d3e1bb92a3087cb86ef49e31d2de6a42690c82dfafd2e82ab0d7986164ef8412"
