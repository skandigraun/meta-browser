# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31b65221ea5bc97986f5132edab9baff"
SRC_URI[sha256sum] = "bdc4e4b5e749307766b54b2475b177cc9d5247f4d06d2b685596b42b8527ef69"
