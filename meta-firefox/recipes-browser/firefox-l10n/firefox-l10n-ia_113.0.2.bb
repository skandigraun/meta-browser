# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db396f208194813ecf51410dd6e54e4f"
SRC_URI[sha256sum] = "46077180353fa2461a38c940e9b0bfacd8f761dbf24d2ac079808d3df3e44e5c"
