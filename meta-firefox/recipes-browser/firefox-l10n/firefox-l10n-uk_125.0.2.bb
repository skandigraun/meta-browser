# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "113b7b1f1a5b0cec54ace9293a89c9c6"
SRC_URI[sha256sum] = "df66c3538478e34dfe98ade6f54b194db1da756cbea665d3a4cfe02bfea293b0"
