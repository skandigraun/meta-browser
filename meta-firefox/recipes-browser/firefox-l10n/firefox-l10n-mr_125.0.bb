# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43a34e75fc9626d487aa072be7a46850"
SRC_URI[sha256sum] = "bd3e91800cd27dc7ca8a54c18d91f1a0b71de4b89c44204e6301e62c56b3645f"
