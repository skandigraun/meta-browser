# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8d22b9f17837ebc41cc651dd11a1b3d2"
SRC_URI[sha256sum] = "2f2b366897eef24d12d48a093331104d3ac0000c94a9413b5c611afa58974b19"
