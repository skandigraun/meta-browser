# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01bbf486921e1c9a3630a5715005bb5e"
SRC_URI[sha256sum] = "a9eafa38d161dcb524d507661594e035acdba47df01088b1f1d7d86b66a47a71"
