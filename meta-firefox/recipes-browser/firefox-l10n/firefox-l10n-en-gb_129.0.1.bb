# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa2fc80b6c99c53037e86a6689ff8373"
SRC_URI[sha256sum] = "40672481f428cc50c7de9a88587363e3e5ce07956fc0de8c1c2d08d1500b1417"
