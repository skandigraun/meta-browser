# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e053f378029ba8584d9d83ccb08c1a6"
SRC_URI[sha256sum] = "1c9b23630a697157aaf7b021cf05b8b6f0f390940a7975b215e19450b427fb77"
