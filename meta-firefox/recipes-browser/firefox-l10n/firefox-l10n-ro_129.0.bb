# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2626337002f29f4f557ecc067e026184"
SRC_URI[sha256sum] = "fad34cabeea080d84adf5b40c8572fbb39bc3841c53d7ee3d8b6c3136efba9fb"
