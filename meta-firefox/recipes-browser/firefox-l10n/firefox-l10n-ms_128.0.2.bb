# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf4524322d0adfa5abb2dbebd943c719"
SRC_URI[sha256sum] = "b47d62f097b9137445def752bd97722a3c9fc79b54cc85c53091bc920ec0549b"
