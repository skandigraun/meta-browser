# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "895474bb5910b249feaca574cbb3e0de"
SRC_URI[sha256sum] = "7aa0353bd464deed8781e01595e54be39fed87b07d80b1ff5c64405c10efa771"
