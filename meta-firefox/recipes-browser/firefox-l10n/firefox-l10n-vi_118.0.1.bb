# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a6b3bb0228a737331e8fc44460682f9"
SRC_URI[sha256sum] = "d7356f0e9c84cfbab722193a50df9783fc2ea9115d1810541aa8b7540cfec235"
