# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "905189bbed95a1674ac5b867116d7ad9"
SRC_URI[sha256sum] = "8132a9566920c90032629c4f2ed66b78a9c6cb9b40cb1a9d0acc261c0953c8cf"
