# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d50f0953a512590459087f7dc5c03b83"
SRC_URI[sha256sum] = "989242618de57d4d228321aa5a4adf15be5a648905963b431ba4ce59fc532a8b"
