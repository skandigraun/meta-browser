# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abb2ec083e4bcb67fd1963373ec50c3a"
SRC_URI[sha256sum] = "d102869077d95ababeaf6bb13dfe6f36f3bd2e9c64b6f9187702fb2be66e31a1"
