# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "479e35f725702d9c449a94ef4534634a"
SRC_URI[sha256sum] = "b55629269279f9cf98b07260c9ffd07fdd0563acf0a71ac132b0fa48b027b9a0"
