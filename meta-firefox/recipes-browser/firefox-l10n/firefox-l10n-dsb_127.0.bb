# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff880dfb4a94b78067a2bbd512958a53"
SRC_URI[sha256sum] = "d3fe0567323ff920fc95e8b24385f316d0c20489c6fd38110cddcd978db1e7d2"
