# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fa8d2e1a6a3f2c05e9b0c2efae4ee55"
SRC_URI[sha256sum] = "1906353c4826487a8ec261e827c3c9717ecccfab907f20a8928271ecda2c6ce3"
