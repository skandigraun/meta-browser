# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31e0ff982269a2f039c929b695e162d8"
SRC_URI[sha256sum] = "e193761ec4ee6b1632a336c10c1a8089394a5337235d55ea511b0dd6d0bd19f5"
