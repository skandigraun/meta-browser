# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51d7192369471fc6867590fa18c7345e"
SRC_URI[sha256sum] = "b6fe1a998fd4d99941f3ae5c3eff1e3f9ca4255b70ecc9d9f023932a1f70cf7b"
