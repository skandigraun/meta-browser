# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3344b75b9230f7dbcd5edc437dfb4b8"
SRC_URI[sha256sum] = "12a6fa84faa19d8bd901a23c5a9dacca263fd8c5482d952eb7a6180b02a70605"
