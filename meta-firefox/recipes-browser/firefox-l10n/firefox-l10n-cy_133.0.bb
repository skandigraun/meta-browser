# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01b42d0771e53c3a57adec8fe6765737"
SRC_URI[sha256sum] = "5c93a04563be50c0420b7eb7a15fe00b5053592aacc730bef1586af3f2d8a5cd"
