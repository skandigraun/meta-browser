# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "061538083f4afa26b8e55f66195a67f2"
SRC_URI[sha256sum] = "56e8e66832d81863984afc03946d1af6c8fbd8fdf4c319c438b4ce2b0b3c3de9"
