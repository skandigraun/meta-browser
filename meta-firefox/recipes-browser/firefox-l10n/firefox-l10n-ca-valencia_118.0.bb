# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0bd3f1a7b0f01647059f3395054fca6"
SRC_URI[sha256sum] = "e2d23de2b470d3d946f43298d5865c92b511cd26fd8362a84eb6ba9372f7de81"
