# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5d516d00188dd570acae2663ca7aa83"
SRC_URI[sha256sum] = "0a18c294ef2a89150acc6521898bed8276806ca607bbb87c6e01c30cc3f6f697"
