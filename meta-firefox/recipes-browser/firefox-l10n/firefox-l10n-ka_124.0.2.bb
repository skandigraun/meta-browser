# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f9af41eb190c54554b16ea576b47a5"
SRC_URI[sha256sum] = "ecf3e4191e8d7c4225137f74699e9d100902d71897a773c6e185909af2ddbc5f"
