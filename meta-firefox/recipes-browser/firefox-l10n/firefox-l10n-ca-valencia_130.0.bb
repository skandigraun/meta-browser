# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96e5e0b686238b845c630ac404558f23"
SRC_URI[sha256sum] = "85696a7b9c6f508c7ba4b39e2014da109699eda8dc9cb7f42c435863efc6d322"
