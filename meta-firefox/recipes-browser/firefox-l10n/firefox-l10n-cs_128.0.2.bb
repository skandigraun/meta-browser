# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cf6627b3dbbb0313005ae0a7c65c0f3"
SRC_URI[sha256sum] = "014cdd4d0fea9d78fc92d8f93a542d7f21170d09ece3e2efa4e35148fe797436"
