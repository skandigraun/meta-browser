# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27d9f209ed718d5c45102c3d18ed21d6"
SRC_URI[sha256sum] = "b82dfe816d3d8dde21cc220ac0aff02dca1640484d5934b06168b38e055ad667"
