# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db0bc9a27bd5fa42dd71aad26ea801f0"
SRC_URI[sha256sum] = "38b2873b86bdc91caaa6da1a5dea426043737a8dcb72c1ed60e434065531a2b9"
