# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2e0b644eabc3f7e415f92c779e7acd4"
SRC_URI[sha256sum] = "d7c1e5126aa39d3f954ab83eb1ce5feb331e7a72be5ec9258e094c787c322023"
