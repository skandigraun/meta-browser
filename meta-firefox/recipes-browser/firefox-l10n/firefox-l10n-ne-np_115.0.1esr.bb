# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73501ec73619a1e7fc398cd8ab1b6394"
SRC_URI[sha256sum] = "5a296b9056f33ef4b0c71a24b0397dfbebe6e4fc89e6a55c30760f15b728baa7"
