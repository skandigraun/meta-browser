# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4e16eb0a448d74f38f12a9abc416f442"
SRC_URI[sha256sum] = "07f6e02abdb8224811372f5a0a3c0a44361c6fea41bda085af1709b87900e1df"
