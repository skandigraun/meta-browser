# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8825571b82b4f70291a9b95747ed2bc2"
SRC_URI[sha256sum] = "d5e536203d70d5e3ab9d5ce431a29b95a4e1c0a73b06d7e0c7458750f85eec1e"
