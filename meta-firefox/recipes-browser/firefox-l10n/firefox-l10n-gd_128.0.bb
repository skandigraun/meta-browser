# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f23ae82243cfda013553dc444005b16"
SRC_URI[sha256sum] = "b8126b54f2162f594721f6868e06fdccc6410bbb99d11df6b1fec167bb46360a"
