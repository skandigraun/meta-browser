# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "251fa0c7818598fee12cd45a41beb9d3"
SRC_URI[sha256sum] = "971144f1216cc1b959ec5e073022c5fe752dd63fe92cff6248f769993648869a"
