# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cda68129f9ff97ec9a48f8f6fe436473"
SRC_URI[sha256sum] = "bc73aa566fe22b95cba98e9f043b60ac9faf21f6dfbdac981b94191b65afa0cb"
