# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5319063ce437aae49ca849c7935e1661"
SRC_URI[sha256sum] = "8b2fe68bd84ea3611c83337c0bb91a83583ec0bcc53ecc277d6032afcfeb01da"
