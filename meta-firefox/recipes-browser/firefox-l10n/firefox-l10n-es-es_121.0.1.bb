# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d38970ec0b0026aee0db10806e5540a"
SRC_URI[sha256sum] = "99383b57567fa123d02557a2c6fe01e0fa1678e1a4bc633bd2b49ab02f76f768"
