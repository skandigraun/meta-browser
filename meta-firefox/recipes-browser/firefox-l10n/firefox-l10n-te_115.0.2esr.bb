# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f77b66617c0f4b10464cf91e5737633"
SRC_URI[sha256sum] = "d36022515a2ac8944e5947b9540767d1fdb32c298a044901a50464d186928ab6"
