# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d79b3d175876de59311b2e0a6608d408"
SRC_URI[sha256sum] = "8e759f9968fb7869327e9f881d467e3e28b01e702194fa33a372c7c7f7a2d876"
