# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56ef54ec30e394cc110c4d9a371a7638"
SRC_URI[sha256sum] = "569d388b582dd5f7fb992a5437b7c91842e2ef3c8163cc7212295b6d9a759851"
