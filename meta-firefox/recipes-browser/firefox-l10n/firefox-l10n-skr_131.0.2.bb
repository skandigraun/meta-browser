# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ecd41348cfc1ac20c0d38f2cc7ae854"
SRC_URI[sha256sum] = "15bde6643c2f4bab0160487ec0a87a30c661698858c395db4631618dfa359fea"
