# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d1d378c34bbad1c8b6ae493045f548e"
SRC_URI[sha256sum] = "56b063aed81e076afabdee1ace7a7b87f49facd5733805e0f0c293787961c78a"
