# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5dbf18e6d723f78c6563a1f99917b976"
SRC_URI[sha256sum] = "9db02980bb6d50dc46942015e57b214a9de6d28b2989e508439d70e32cc5e014"
