# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a93a5a5bba34c806a86be90b5944f58"
SRC_URI[sha256sum] = "ece2b61774c32391d5ff64c4d37c3a310d291ef87299c321679cc95e29a67fa2"
