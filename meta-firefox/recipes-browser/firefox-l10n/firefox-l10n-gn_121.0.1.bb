# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d81e92574a68a7307f36d8fec232e2b"
SRC_URI[sha256sum] = "738f6b443ceced5d232296eec26b4190796c4261e7929eb6ba6c9848e12c8680"
