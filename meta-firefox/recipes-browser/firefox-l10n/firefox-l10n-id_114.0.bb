# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f7ac0a511f31dc7778a13ce636f73f0"
SRC_URI[sha256sum] = "63e53aee3ca63d086778c3b66d2e0530c23e901dc4e2a437e8bdba7bcb6ee720"
