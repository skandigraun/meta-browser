# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55d8ed19d040cf60cb22b4dbeabfa68a"
SRC_URI[sha256sum] = "fa35b0ace003dbfbab4feeba13d53ee41e2a769b61f30da3e2267a871f110b91"
