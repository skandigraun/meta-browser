# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4f1bb02dcd95376b304579c8195f957"
SRC_URI[sha256sum] = "b7d3cb6f8bdff72e3bd78c0105b145294e952e15fdc9fb6e87c6002a2146f56b"
