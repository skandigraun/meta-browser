# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0e0b5118df1a2fe7cc17a6540bfec137"
SRC_URI[sha256sum] = "e196409093e9f7be657eb24fc1939c7dfb434bb3efaedfd257767b7aba63a836"
