# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ac562e54246903ff557b0213a07e3db"
SRC_URI[sha256sum] = "105f1f34150f8af3d7f458a131f0e40a4691c94a50bb165b8a59dfd1338a8229"
