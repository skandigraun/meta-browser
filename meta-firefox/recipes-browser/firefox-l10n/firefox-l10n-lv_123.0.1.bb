# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ac308655c561fe3bb825cf9fb0c4e0a3"
SRC_URI[sha256sum] = "11b3f7b8e2d93c18e37ef96a14bba570a7f7a9782db1eb0935b339882f5f5f37"
