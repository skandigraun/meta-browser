# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1424308fc7ba53e9e3492885909d0cd6"
SRC_URI[sha256sum] = "dd324051beb87143503004a4d4320b838843a94c4c28b318313bc2fc134a56ea"
