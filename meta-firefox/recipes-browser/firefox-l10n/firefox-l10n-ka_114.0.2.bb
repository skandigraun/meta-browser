# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4436f4da02a4df03ad2c2b812c18d2b3"
SRC_URI[sha256sum] = "af0475b1a26d439a2f0fc1ec97493a08029e86f2ef73f7f1d3c3898aa3ece77e"
