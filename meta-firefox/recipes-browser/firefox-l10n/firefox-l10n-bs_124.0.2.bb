# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdf747f2087a2a11f0e4335e54dee40e"
SRC_URI[sha256sum] = "cae3871a6502abf6160174d34f1d8ba061e292a8232d645379dd3938af9f611b"
