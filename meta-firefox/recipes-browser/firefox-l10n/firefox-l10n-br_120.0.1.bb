# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eae82c4db3774c9165ff4ed8183e9f7c"
SRC_URI[sha256sum] = "e686af7f2400c4b95e5306ac7267eeb675fbba1f6425dd224ae46a8911e435d1"
