# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "368dcbb2f4c43b4b4e8f958cf7f47b36"
SRC_URI[sha256sum] = "f211635f7746712aa9b994b3f8928b064d0801e438130c793577b4beeb44a2b4"
