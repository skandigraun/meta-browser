# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13f1913d9d6987cdde7dbef44fd12323"
SRC_URI[sha256sum] = "1a1924c8e5f27605d38dab0e1221a81c287eaa3951f30bf5a8063cfa993483ee"
