# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "858737149fa1e31ee01090af1206a295"
SRC_URI[sha256sum] = "3bafd2062e24b69d59c21fcfdc60f621ddb3b2a52cd77b784a8408b8d6a6ea8b"
