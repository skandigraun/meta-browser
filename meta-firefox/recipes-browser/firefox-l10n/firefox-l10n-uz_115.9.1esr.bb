# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1dc4f96c1167b178275da6620eb4543"
SRC_URI[sha256sum] = "4a3695456edefb58cd65bfe74d045e81daa0d7f021c3581595a00af49765c735"
