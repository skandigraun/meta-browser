# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9641193afd7b73e6f51df9c3348a5301"
SRC_URI[sha256sum] = "c02c80bd7998fc2a905a2973967a8db64f92d6662f5e050ef59d1cb112619f27"
