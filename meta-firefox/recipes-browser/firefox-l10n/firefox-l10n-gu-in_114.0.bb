# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dd2f0b5e847972d29313b66407075beb"
SRC_URI[sha256sum] = "e5abcec84157c0085f99b2f4d0cce258d3dd496a8edb7fa208937da8fa7436a3"
