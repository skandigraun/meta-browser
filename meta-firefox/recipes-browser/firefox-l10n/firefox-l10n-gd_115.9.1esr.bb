# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6c6c54b71fc5c04f159aeda5f86f324"
SRC_URI[sha256sum] = "44621a332a25003f174eeb6de09d543e60eb60254110d897b50266e1106f6c3f"
