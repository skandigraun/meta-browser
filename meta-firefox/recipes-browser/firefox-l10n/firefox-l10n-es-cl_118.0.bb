# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebbd4022d0709a95907c5f7aab8205d8"
SRC_URI[sha256sum] = "80dfe3de458c88a96258e316387e55cdf31cb41d25fd296278178dfa990aa2f6"
