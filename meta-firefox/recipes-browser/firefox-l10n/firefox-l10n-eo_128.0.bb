# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f43c29e11bc5a17dd8dca576875362fb"
SRC_URI[sha256sum] = "0ae43b5ec0d5e0099fb5231c50753627d62cc16b47cace3dae2a863500e0a4c5"
