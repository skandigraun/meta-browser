# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdabe75997e30f42d60fa42fcacd96ee"
SRC_URI[sha256sum] = "c49fcbd4e74259a4f17051ef809f2fb596308a7cad6819bdfd407a96b1be21bf"
