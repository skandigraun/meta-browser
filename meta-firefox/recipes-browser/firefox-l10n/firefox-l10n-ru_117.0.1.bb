# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89d7ed23bac2b3b7bdcbd137aba551fb"
SRC_URI[sha256sum] = "3aaa982abcc9542d1acb782159a2c3ef348d2d176ac54745625ead58d8fe39e2"
