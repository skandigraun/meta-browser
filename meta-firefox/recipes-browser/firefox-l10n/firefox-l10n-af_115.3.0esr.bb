# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9a8d8e14c1e88b1106e75351ec78034"
SRC_URI[sha256sum] = "0037daf74fb6a98da5a1ff5553024bea3dd10454b5033b2a4925a97cc1c10329"
