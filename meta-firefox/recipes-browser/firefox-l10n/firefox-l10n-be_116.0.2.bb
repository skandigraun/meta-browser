# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cfa5950f28aaeeb1f1f8cd7052ed3b5a"
SRC_URI[sha256sum] = "cbad29ab55fa335c290dbbb07b99d7a4130966d655c2ded3ffbc38268c20226a"
