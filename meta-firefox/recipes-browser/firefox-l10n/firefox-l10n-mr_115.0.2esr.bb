# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e445c7e83b81ef0b3d7d5cc2bb40c1b"
SRC_URI[sha256sum] = "caeae3deb819f2d42fb0631ed7f9fcaab1d1983a09c336b9f4c00d0c81be804d"
