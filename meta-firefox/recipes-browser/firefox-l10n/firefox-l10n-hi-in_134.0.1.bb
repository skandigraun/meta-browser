# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a19ec293adcde5e1982600b52c068668"
SRC_URI[sha256sum] = "e8378a72042e4a896f2ce6c711f3f7ce42cf27df716db536847f42f1bc71d5d2"
