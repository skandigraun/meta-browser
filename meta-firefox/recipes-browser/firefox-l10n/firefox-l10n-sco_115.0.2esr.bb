# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4db6909f45144057742f29488ac66839"
SRC_URI[sha256sum] = "c05207300298d3b9d94ee187cd30b5a96da932338f08cf4094bc8344efee76ba"
