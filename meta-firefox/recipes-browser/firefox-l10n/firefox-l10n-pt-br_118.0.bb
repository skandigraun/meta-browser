# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49d81ce7e8103165e85df74bab87dd2e"
SRC_URI[sha256sum] = "eff9434d2e3a02c177a7c49e8ceafca8f1820a84451c53a471fdbd0975fc8a09"
