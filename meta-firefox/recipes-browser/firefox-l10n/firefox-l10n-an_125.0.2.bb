# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dcec3d58feed5c04f0de1f45efbfeac2"
SRC_URI[sha256sum] = "8fd68f697c55742bf62664beedda2487b1b3c3e1aec31197113c9c984acc69d2"
