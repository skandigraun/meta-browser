# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cf45ec8293c7867eb4b132c6e94c1d0"
SRC_URI[sha256sum] = "3e671a6b1bb39a12bae6fe3d36804e0be7302be8e61c3c0e17ad535f64424d77"
