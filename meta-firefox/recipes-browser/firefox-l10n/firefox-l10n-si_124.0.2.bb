# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59c9308e804848c7a4eaba459fdf340a"
SRC_URI[sha256sum] = "e980e0a78aadaf4ff6e33e95d7ec32fcc440e4f18549a713f78f2f4b7c5226f6"
