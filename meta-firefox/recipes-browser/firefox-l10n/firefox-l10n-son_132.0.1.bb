# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "407b3cb0bacd666e891891649570ed1b"
SRC_URI[sha256sum] = "66fa198c7bcc0633689c2ee3d05c2f2d9216ed05e995bc8df15c9e4969b0de1e"
