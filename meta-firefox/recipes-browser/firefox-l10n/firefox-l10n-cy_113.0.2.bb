# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8e45066e4a59c5f9cb199f5d271d4b0"
SRC_URI[sha256sum] = "e8e474e58bdfdad65cf72e8eb9e819ac5b551a037cad88df7b6767885879ff10"
