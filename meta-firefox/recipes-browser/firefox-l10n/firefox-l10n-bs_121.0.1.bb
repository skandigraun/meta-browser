# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1255b72b0da0999b433213692e35789"
SRC_URI[sha256sum] = "9de2762d79505a59deb7da2ab08070b7617027503de3f6ee3c8a2f3f077fb654"
