# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1b2270e5b54b838f7a853cb6150fdb38"
SRC_URI[sha256sum] = "a699871947d12d0b5ec918d6a120df57b3708dedb70bfadf5efacb7d1648dae1"
