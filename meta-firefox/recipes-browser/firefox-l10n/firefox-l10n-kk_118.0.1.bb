# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "805d5b0bffccd810475fae63a5ca493e"
SRC_URI[sha256sum] = "8fc9204fef05c935fb11b413cda08dc8c350a2d7fcab24cb7a9c0ef0750bbec3"
