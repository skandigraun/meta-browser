# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e0b11aaa3b3eb0db7b0540e4dac199b9"
SRC_URI[sha256sum] = "79d9a9892646ea2b9142d4cf14954ed8c0f6a6e314024ed9c49873fc41af93c7"
