# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b648500dfdc5275f436a9c6d2db1677"
SRC_URI[sha256sum] = "bf0d02f5313fe0214a1f21f2dc95bc40072c94b07aec51eaa01430ddcb2e7c28"
