# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4cddee083eea5a77e29f22c13225cf2"
SRC_URI[sha256sum] = "282b0e3f0b8b6aecb9e46ca6e1b62d7cbb5f526268948171a74119f4d7f32c65"
