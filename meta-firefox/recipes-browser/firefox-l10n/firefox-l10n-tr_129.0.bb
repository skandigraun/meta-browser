# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24c2a38a1ca10c6a9c0a8530685cfa38"
SRC_URI[sha256sum] = "36d1e6436392e8d7a47d27d766bdecafe4a05f82c5a2cc9971dee60daad3a872"
