# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53a5fdc3fbc73b894669e3378d11da32"
SRC_URI[sha256sum] = "a317921cf58adf9d3e2afe294ac237781e57c272b2845f5595e2fc7365ba8f01"
