# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a97d50dfc743f8a4722c027749df08bd"
SRC_URI[sha256sum] = "74806009bef217390b1ecb174a246e12ec31acfa741b72027ce1a9ead88880c7"
