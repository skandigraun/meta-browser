# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "278be17a63092575e5e1099137efccef"
SRC_URI[sha256sum] = "0bccf657181927faefc153a280c8ed5171936b39f99b934d75d25499ab164877"
