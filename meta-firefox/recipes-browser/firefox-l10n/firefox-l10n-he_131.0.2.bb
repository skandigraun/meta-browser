# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "531b1e8780b719e88b8509362b52055c"
SRC_URI[sha256sum] = "13b2c25426e385f19a6b5886c9760987b46b2a7a3add19551ccda9a7c4b5571e"
