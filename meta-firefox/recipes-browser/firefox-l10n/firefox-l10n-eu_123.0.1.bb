# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72a48f06b539f944d83a8b0b50683724"
SRC_URI[sha256sum] = "85e111d4cb9379c28efdb1a88cc831ea73233e5c8f0ad46158196be78f0a50cc"
