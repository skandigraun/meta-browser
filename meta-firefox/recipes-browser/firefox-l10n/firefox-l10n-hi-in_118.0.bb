# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d2951dc21a964da37b008b4511cfeac"
SRC_URI[sha256sum] = "7f93215a10f2f18b360aae717c0c04bea94bdd75ad2558b310f631b04eaad2b4"
