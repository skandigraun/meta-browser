# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e90a5c393c02937874f5661194695195"
SRC_URI[sha256sum] = "8efdb2d9c59e458de8f34bee8416eeba1fcb7f586aed4b61bf5499be8a9f8429"
