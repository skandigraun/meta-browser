# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cf9b37ebb4faa66280c1f37db781f76"
SRC_URI[sha256sum] = "9a62704ddc5cb42ca51992a23fc4ca07472744a13fd3eb349c26a0ea00c401f5"
