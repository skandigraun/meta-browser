# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12214213ff6929431f3fc7b52bba1736"
SRC_URI[sha256sum] = "161997f8af881a4105dc1f6cae34f26cae0f7f7a5694196f0ce7491de75d6b1d"
