# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff6151c13f31b0a27c4abc1c58c8969b"
SRC_URI[sha256sum] = "c47518dc1c0c77a3935132140d569c060e15b7975a6f3fe2745aa06ba71549bc"
