# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5da7db7a58aaff51ff7424a7c8b9c9e9"
SRC_URI[sha256sum] = "5fed1cd0b348c084f08f4cdae6b73041af8ceb04fcd3a4bc43ad79f2b8fd436c"
