# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c45dc70bd3d3bf2949e7ef1532c27a8"
SRC_URI[sha256sum] = "5330d3c6aff7005a9fda8f4f5c27bf43e38948595eecf19a1738fab7dfe32134"
