# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaed835255333632e347658f7c6cff84"
SRC_URI[sha256sum] = "b53a834b46964a818d8fb088734791813c084a02b92d63474b6372c79f6529f5"
