# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a22df922b9bdb7b6cc898b1658e48802"
SRC_URI[sha256sum] = "e67f9d7268fc9a1b01d972a8dfef9cace2336f508cf8c3bf0f5b56ca13c327fd"
