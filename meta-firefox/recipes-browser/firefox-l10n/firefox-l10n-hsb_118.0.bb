# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d881dae9c3a0ff28503514632fdb3a95"
SRC_URI[sha256sum] = "0e498ed5d50ecba01f810dc2eecb91a70e225ac0621efbc0b8883f349f1d0b47"
