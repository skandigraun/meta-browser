# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1af32b72c09bdc321223d3616f331d34"
SRC_URI[sha256sum] = "245749cbe9eff8e7e629d5d246c081e2e68123851a324198daa327dca4b9fe61"
