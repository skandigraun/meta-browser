# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9594485e5cbee576442f87452159bbeb"
SRC_URI[sha256sum] = "9e859486344daa290f254e38757c4691da11e9d4beb2d647ffc3eccf94aee232"
