# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "628f724e370f8e20be1536f21081b857"
SRC_URI[sha256sum] = "917c63dba371dd19b2b22af588b4f6f7f3f52742b4059272cfe82dc51b061c40"
