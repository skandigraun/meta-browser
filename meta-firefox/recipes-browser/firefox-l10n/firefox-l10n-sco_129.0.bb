# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0aa0cc37bf8ac5ef98f8b79bfbb1d4f"
SRC_URI[sha256sum] = "aae681c5c7fad455be54fd630727189fe7ca4e4a9e2eb75386fd9a4a35450b97"
