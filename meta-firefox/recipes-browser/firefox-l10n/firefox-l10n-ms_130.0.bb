# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b60dbe96af349e45df8d24b75ae258d6"
SRC_URI[sha256sum] = "430403caf508814fb110308cd4f0aa0808f4382a3de1763f39b109372fcc269c"
