# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "949c6028154cab24804c3af2c969b0f7"
SRC_URI[sha256sum] = "9e5e65868715560e61dbcdc2e5f1b502229a25b8654ccf63813695c41f1eb632"
