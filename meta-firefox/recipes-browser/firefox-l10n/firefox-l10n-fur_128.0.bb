# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7be6ae3223088a53c7d92a23d8389dd2"
SRC_URI[sha256sum] = "1966c9261ca6e2d0fab16a41a3f0c981fb293c313943163af53ef11dcef10ffb"
