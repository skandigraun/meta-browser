# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9025386b232254b4cf623aa46761d8d8"
SRC_URI[sha256sum] = "bdf8a2165a818889a687402bf1e8884df71a446db37d3ba1a05f1cb163c2a020"
