# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e0ddb353e4406be26f16e90a27e8892"
SRC_URI[sha256sum] = "7d643c2d7e748665be51ff78b37592a0aca7d4459076ee945a1fef607b68e7a1"
