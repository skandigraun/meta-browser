# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96f8593d983beb485ebea0f1840fc484"
SRC_URI[sha256sum] = "dbe1c73bf0f235e573043b5738691e53f86ce33219669fa7d9a6930094b4565c"
