# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bd59445a251fdfb50a374ad34e18a01"
SRC_URI[sha256sum] = "62c4a9faeb3b78b6ee0e7d7445d67faf2fcd5dbc8d31ff53012986ebd67a20dc"
