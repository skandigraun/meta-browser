# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37b4f5e1041bdb2ecc73969f5f39d212"
SRC_URI[sha256sum] = "0757429513719c7ffc65b5575a6ba167792eb84ee88628ba35de7e76f90d9e30"
