# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cf558fb91e0613c9ef56f301614334e"
SRC_URI[sha256sum] = "373594d6f6cf4e9e6f144bdb8ed31c207da295203dddb8c4fd6c85b43b3e225a"
