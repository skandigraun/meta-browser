# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b5f54427d7eebea09eecb7e63e6b04e"
SRC_URI[sha256sum] = "3890f6fcc967db23914ee090edd31ca03622e359d7ca7fe5ebb92a203d63f17e"
