# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f43df58a15895a46fbc0dab7c211ee48"
SRC_URI[sha256sum] = "687917f0949b2bc0b8cf3ea20308ad31729661f292f749275890144276a638b4"
