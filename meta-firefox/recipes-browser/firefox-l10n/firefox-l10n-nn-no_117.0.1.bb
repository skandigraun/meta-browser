# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd64091cdc4eb6263b2bfd15318b745a"
SRC_URI[sha256sum] = "43ecfaee5e94657b74ad68ecd435969ad95271141039b985175aaf287a038d93"
