# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e66d4a47717351a421e735b39a721b1"
SRC_URI[sha256sum] = "6fd0f4afff92fd566bafd19ae2dd9fe388ae9e365ddae0996d5609cf9c1dd6b4"
