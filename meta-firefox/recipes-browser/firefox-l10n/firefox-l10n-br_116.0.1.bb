# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eaed9ec45725a55fdd6aa2ecfd6eb1c9"
SRC_URI[sha256sum] = "18ef80103990c66e1cafe071ec37f63b7d302c45490757df7c962892a2ae2055"
