# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5987b4b840774317942a9b406ea4cf19"
SRC_URI[sha256sum] = "127496ffb405df188e64eaa3e5b5dc4edd773eacdbf92cb6cdcfce93e0743a84"
