# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95544472c818dfdc85a8f65e25c7756a"
SRC_URI[sha256sum] = "20e9c7514e8e4a135c36cfd32177fbb000072e2fe3b7a38ea3e08ec2064d9633"
