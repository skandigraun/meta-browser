# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c1d8f0ea3477e06cc7b683613b84f2f6"
SRC_URI[sha256sum] = "6693279ec18bf40761c127b3f74c98afaa6bd039c4366f1b00f03c9d66e8622a"
