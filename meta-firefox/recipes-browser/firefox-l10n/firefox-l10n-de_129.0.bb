# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "54c0005d87721659569c1821db945eae"
SRC_URI[sha256sum] = "78dacfe7d9b880c39111982dd1763eb6e54af971e8290ddca8165c344170ccc9"
