# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae0ac7f9bc1c25147cd198a8c237f5e0"
SRC_URI[sha256sum] = "cd0e68d0a78738d69444bc5b814d304f65f775332d39b5cf5f30a3c8ba64c5a1"
