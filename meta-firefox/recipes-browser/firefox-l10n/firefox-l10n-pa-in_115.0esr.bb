# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ddc323a7a2ed40f26c209986f9a38aa"
SRC_URI[sha256sum] = "aed42cec2a7aad2424b6aaff2a63613a491b1696dee9d08c7b3187617bcdc151"
