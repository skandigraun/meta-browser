# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45b65aceb53236ceca38b09abd68ba49"
SRC_URI[sha256sum] = "c035fe414c2f98c26fd7b15dce279016577ffec0b31ce9c57e26f1d495dae7dd"
