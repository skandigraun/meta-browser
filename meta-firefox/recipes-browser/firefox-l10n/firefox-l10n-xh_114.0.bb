# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12899e43e0ed4127efe1c549f94d21f6"
SRC_URI[sha256sum] = "03bb0e45f2038e8dd5d57ad131c163ddcd135cbf1b42371670bef4fa2fdf8da3"
