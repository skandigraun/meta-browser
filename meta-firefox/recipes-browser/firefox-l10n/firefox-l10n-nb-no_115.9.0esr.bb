# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e574ddc75ae8838e6d0f81ee42f5aad"
SRC_URI[sha256sum] = "d71390fbc4fdf6d0d0ca2edc016d3b17eadff3d295b6034e0746f7cdeae539ae"
