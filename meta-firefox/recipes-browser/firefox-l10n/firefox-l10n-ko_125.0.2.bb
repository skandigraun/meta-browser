# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a2e5deba35ad94ecb1e7f09a0dda249a"
SRC_URI[sha256sum] = "df47f1be44fcaf7dcde626cca4d3caf5866713fad90493feba050a05524973a2"
