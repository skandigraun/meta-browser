# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7506fcd37f60b2b9735e778c5f2e9399"
SRC_URI[sha256sum] = "0ab86508a678e70ddb2edab01929f52b325c8235ee63e9186ef545962aef5640"
