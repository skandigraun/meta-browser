# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "979a8042cbc5caeff5b4d513a7c0c57f"
SRC_URI[sha256sum] = "0ef94e69d6719da0511e6ec8ce5d38748fbac371013540656ec237804176b2e5"
