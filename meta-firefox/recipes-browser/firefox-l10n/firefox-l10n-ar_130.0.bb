# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c9c5c0dad1d021cb4a600999ef448f8"
SRC_URI[sha256sum] = "783e998cf39a3d7302464b2d0da4378c1e4736af976297da3e8847e15919ffac"
