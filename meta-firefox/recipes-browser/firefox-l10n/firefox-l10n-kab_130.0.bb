# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bd50e19a1ab65589d93d50d92c312b4"
SRC_URI[sha256sum] = "7ba12009bc366c6bcfe464f39d44043cdf888c9ed3bc4eecccf3c5c046eac596"
