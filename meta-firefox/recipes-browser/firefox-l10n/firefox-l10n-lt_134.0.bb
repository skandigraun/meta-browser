# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a32dbbb8a7f9491ae5c1df57c4a09b4c"
SRC_URI[sha256sum] = "21cf30ed298ac38dc63ce35296c21ee597f2518b955a80d20232596c1086393a"
