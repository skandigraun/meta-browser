# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aca1c18d976523bd981beefa93362799"
SRC_URI[sha256sum] = "011fa26ae4820a393c7f4b0c21af7ae1550899fc062705d5357f505260d384eb"
