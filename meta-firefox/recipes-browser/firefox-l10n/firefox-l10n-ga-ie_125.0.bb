# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75644d5068b100246a647e42fd11af32"
SRC_URI[sha256sum] = "ec481e3c418a40025e4a87eddd5730416178bbc68338594bfe28ee90b9e058ee"
