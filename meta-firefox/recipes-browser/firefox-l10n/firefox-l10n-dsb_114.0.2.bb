# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b32d3f5e33383240d3b4442464656b6"
SRC_URI[sha256sum] = "8efaa4e6465df40eb4203acb5e204e8504589b39d5e25df7553c581a8a5ea2ec"
