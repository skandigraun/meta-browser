# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41edce07923538361bdae94391b7193b"
SRC_URI[sha256sum] = "a607e10a1333e22495b4e3a06e1031d214bb498da738fcf8d36ce53b1352b6ff"
