# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d052092016bae47733f7499b05cb27e1"
SRC_URI[sha256sum] = "95fb05a4001f46f4470d133f46337c2f285102c31674e7f93eacbba3f05d5529"
