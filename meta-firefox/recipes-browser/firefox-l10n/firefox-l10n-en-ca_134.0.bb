# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a22c08e8fa297c03611ff2a7717ceed"
SRC_URI[sha256sum] = "79498224ebf702a2b7de3fb1699df3ded757cfd89e4537076d314a62c04806c0"
