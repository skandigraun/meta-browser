# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b9db851adf2308c0aa553ecc27e1deb"
SRC_URI[sha256sum] = "40edacb2d486f1a03188e7790e13f19597f2ab7c49ec89d3c677cba5e19c38a7"
