# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5fab7f8b0a7c10137df63fd4d741f13"
SRC_URI[sha256sum] = "f0a5a9c8bdf4a356eb6ecc62fac17d511c1678d3acb3b27721db57c800b7d376"
