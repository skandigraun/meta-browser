# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34bdbc777e6d955bf024518a262bbb2a"
SRC_URI[sha256sum] = "683c35b16272b5a7d61103bbe62e94ecd1588225e5f933429022d474ae1b2b71"
