# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f29ec0aa2ad812d50ce55075b5804794"
SRC_URI[sha256sum] = "31500bd8e02b8ffaa4d9b0c8f1d2ba6de217d056bd1b15e041b3bff48091f839"
