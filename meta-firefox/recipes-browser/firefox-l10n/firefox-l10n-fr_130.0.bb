# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d23f3afc8679a0108f3c6a45589509b8"
SRC_URI[sha256sum] = "4b3e7967688e9d2efc1406a5df4ac30df21c96348e8bc0aa996336aaaaa8de02"
