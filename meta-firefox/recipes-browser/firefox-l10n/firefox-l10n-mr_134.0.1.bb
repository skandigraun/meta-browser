# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fe0bcd7159c2685f2cd5d8ccee045a0"
SRC_URI[sha256sum] = "bd6db7463a186c4625ac3dd509df7e9bad96b455c075e431b211c63cc4089a91"
