# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e55a8e7aec6528c0c92f1b6a1fb8beb"
SRC_URI[sha256sum] = "ea1fc44b0e1a91c8f0331df54dffa06d69afecd8308fadfc1603981b94df2aa5"
