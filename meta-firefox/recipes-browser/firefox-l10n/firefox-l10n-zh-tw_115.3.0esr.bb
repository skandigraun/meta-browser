# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2fc4dca1a25fdf9ceef14e313991885"
SRC_URI[sha256sum] = "db3ee1dc25622d00716b0a6a6fd170ab6576b2c8dc0deac353f4ca9b3277d7d8"
