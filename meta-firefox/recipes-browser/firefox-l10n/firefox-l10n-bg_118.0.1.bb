# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fe30e8b1345cbce92715b99ecca6b6a"
SRC_URI[sha256sum] = "0bf9285ad12b2f080f98b31948153f5a321573f73d6182a79e52e2144fe6b675"
