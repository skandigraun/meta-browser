# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7919386547aee58e38d948342b0a736e"
SRC_URI[sha256sum] = "45808c2ca72a3ccc3c8f121799230e60c268daa173794a28d3c8f23b012853a0"
