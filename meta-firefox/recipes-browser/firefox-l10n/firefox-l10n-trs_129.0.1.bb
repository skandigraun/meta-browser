# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2219d5b4a7b3f789208ee7322433d33f"
SRC_URI[sha256sum] = "85ef8e3d9b0c205846b3d40e90312526de3ebda85c1480cff9ce11aa7a9cfbe4"
