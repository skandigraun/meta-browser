# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "702394ae59dd8a0d86d98d94125185ad"
SRC_URI[sha256sum] = "3d868f1fb10e35d895d8cc2cd9ec157d879427a50c60fefdf820b7370498a408"
