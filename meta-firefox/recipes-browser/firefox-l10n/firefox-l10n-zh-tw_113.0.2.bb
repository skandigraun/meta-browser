# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "023b281177d69fcc3e2d71bcbeffc7fd"
SRC_URI[sha256sum] = "c6d59ae499501711270438ef39658feae851098d33dc9c2a6722d5ee3ffd8935"
