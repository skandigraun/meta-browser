# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d15cd9e4b9bf05bb15c4a590b3b080f"
SRC_URI[sha256sum] = "935894e7c9c64356e201f2dd78636dfac212404c3664c8dad5bc85ee341f99e4"
