# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7ca0d65039030bce709fe979eb07931"
SRC_URI[sha256sum] = "ccf861a63943ebe6831ba891aebb8aaabd74b1635de8ae5e69639cad0b26bfb8"
