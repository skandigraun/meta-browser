# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a03a58b0565192ecf7a1ce986a124fb8"
SRC_URI[sha256sum] = "2eed639cef455c160c98113d94680473006870ed3a917d8c0450d4278ccd4895"
