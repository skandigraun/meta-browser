# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebf6eb7565f12b990c97dae8bc71c151"
SRC_URI[sha256sum] = "5fc758afff874015d07da48a84a8d98935ee604614d36f1f7e37ac79228bb9c8"
