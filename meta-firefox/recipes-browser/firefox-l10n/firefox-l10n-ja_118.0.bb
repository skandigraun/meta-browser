# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa292ed4818d7b1d74b4cdee12bf08ff"
SRC_URI[sha256sum] = "af32681af927ba9187240efa157584c186fb86511840df434c86944c39301a14"
