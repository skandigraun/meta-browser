# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "335d5276e1a207c402e6ddb80b47d88e"
SRC_URI[sha256sum] = "f655c3382fd896b4c34d3e41dbb568052fa4d57523e60c1b71b33b09d495e88f"
