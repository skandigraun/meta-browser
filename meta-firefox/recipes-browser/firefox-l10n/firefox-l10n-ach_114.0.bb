# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "874ab7ce421b1b11f05b943722ca94ca"
SRC_URI[sha256sum] = "c0f9a6c3d766c08f3676602696d8798b679ec1388cd5392a1b8668ffee145ffa"
