# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81af64a72f1603d5a93c0f61b619161c"
SRC_URI[sha256sum] = "81e1c637ea3ace84ea209143258824d7dd5389ece2c5996f98156e995ab9ba84"
