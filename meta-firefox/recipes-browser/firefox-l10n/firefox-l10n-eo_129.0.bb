# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "796f8f7b1e712e1b3dab4ab9b26bd958"
SRC_URI[sha256sum] = "66c2f040d779dc56d37908abae848c79c450b1862ed06d2f98fbb107b3108033"
