# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b7e664ded0d38f657a8f094a3e812b12"
SRC_URI[sha256sum] = "67cd173dbb4f9c74e49e2e4acf7a1250aaf8a91ff1a4efcdd0a365198045bfa9"
