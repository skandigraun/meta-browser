# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e23ac19b8bee4cabe6ba8c2b062ac9bb"
SRC_URI[sha256sum] = "4d8106bc38b90a000a429acc1b3f0bc1cc266d259b2f4bb94a2e31eaea5c99e9"
