# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4f23cfa7a0103999b5d8ccf38220f7df"
SRC_URI[sha256sum] = "c511849d370b5b2c59aa63d497eb7e9771862b449801f064ea15f65848aff1b3"
