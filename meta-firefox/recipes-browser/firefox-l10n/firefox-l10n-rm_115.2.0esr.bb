# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "921ef1e9fa7ef4ba3b5bf90f908ac012"
SRC_URI[sha256sum] = "e824c91599b1f6530618b42e9f36281ee2ad7501a5428834310ff3660ee170d1"
