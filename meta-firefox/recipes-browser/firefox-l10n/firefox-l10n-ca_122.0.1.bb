# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "413838c4f102c920557edab09a7292e9"
SRC_URI[sha256sum] = "411f89ba3d1547f8b9751fcf0b9b5de81fac3047c6a6a03bfcf2a879172fd7a9"
