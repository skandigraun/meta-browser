# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4431cc852c58733aaf74b5c19b0cb52"
SRC_URI[sha256sum] = "ea0544f2818025555c6949b38e26f8a7f51963e5a8cca9fdae136a430f8032ff"
