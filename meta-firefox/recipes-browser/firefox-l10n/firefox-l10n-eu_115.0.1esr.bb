# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6c37804d6866f87f13d07c454bfee5e"
SRC_URI[sha256sum] = "3e8aaca2964c38e61582c40fb768735c526440a866dec95254dc2e8cd647821f"
