# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44e2e0b0054cf18f298bd25ba870fd49"
SRC_URI[sha256sum] = "7cdf88a003e5df9ffccf8f67f73dd4f14a34fc49f3d42292f2d19f507e437ebc"
