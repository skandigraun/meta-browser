# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9575ff5b2aaed255b068003bd844b04"
SRC_URI[sha256sum] = "b781171c6035b7ddf098d20ae9e4e52eeadf32b9ff65302792b62689aeb7f3d5"
