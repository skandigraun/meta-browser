# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c6f85cc8f37cc5305292d1a7b80ea498"
SRC_URI[sha256sum] = "d1a22132f60627206f1e3800eaf6e3861e0299891ec82795dbf9fbb4e6fceed6"
