# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77e5864191859728854d52aa4472dc50"
SRC_URI[sha256sum] = "4d052395fe26ef28bee3a0c48bc88e931163c1b5f828d62262a6b930ea5ef539"
