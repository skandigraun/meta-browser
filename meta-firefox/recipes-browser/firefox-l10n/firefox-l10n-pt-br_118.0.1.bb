# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5784b3bd09120a5792d433035f599f5"
SRC_URI[sha256sum] = "6b41c9502ca20aee0e4037475d14e7f9b90a9b4463994d381928c7516d6ed165"
