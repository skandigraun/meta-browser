# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b99a366ff6f7511904ca2cf61b8326a2"
SRC_URI[sha256sum] = "ce142c2b4ba23d1499717167dd235d0ab6031c83b3f5df7a4d7929ebf1024fc6"
