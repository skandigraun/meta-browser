# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "991498cef0df3513fe3fe3ea4bde5ef0"
SRC_URI[sha256sum] = "135679c75e6b0577ca5988a0d581a93571a70a0d7950c9bb2a4684dbcc8d38e8"
