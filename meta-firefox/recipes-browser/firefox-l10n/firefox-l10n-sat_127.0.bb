# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f6c96a7268fad7682c81e61d17f6605"
SRC_URI[sha256sum] = "8f7ffba532aacbc10102bc1c32106f9eb80a1197bbc6ae5901ecee12f0b5d072"
