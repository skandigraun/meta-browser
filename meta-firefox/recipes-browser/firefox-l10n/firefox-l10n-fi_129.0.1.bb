# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a81870046c6b9cb3e71e7fccb99bbde5"
SRC_URI[sha256sum] = "4aa144d4d25ee23c8ebf073c5e97970d4d4c43b92c0a266abb77cda0a27914e1"
