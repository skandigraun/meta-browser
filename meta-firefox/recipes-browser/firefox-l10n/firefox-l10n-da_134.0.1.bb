# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "324a300d0b8210f3cba44304a7075d38"
SRC_URI[sha256sum] = "18ba64f3f1858ff89dac1dec07f5988507850ad64f3ef7ee1c7980291403e611"
