# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "017cb2362dfef2425988655e4add827d"
SRC_URI[sha256sum] = "9dc3d4a4c8da9ca943025c0cab2d79866e10cc4ce495377ff0097f2023f3335b"
