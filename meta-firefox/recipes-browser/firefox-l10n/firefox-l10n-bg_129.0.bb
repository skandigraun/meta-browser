# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f542be562cc918e2615e4ac7c83e6d55"
SRC_URI[sha256sum] = "ebd4070b5aae9ab76e4782ff5fc82c129bc090ccf8ccaa9304e76f14e3e29f77"
