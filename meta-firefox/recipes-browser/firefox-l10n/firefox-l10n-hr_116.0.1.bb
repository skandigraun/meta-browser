# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4cc3c6b332db1e5e1073d22bb0d312a9"
SRC_URI[sha256sum] = "86289fdfd0a5607842c174ba304105ea9f9c8a213c42a5cf85fad98c60e5dea6"
