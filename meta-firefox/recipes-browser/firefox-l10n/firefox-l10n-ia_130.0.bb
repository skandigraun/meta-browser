# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4659dab4880236952e069fda83307a43"
SRC_URI[sha256sum] = "9ef54361f3f6b828a3838a3d87cd4d11f67d996c17276eb6c232b457e023e57a"
