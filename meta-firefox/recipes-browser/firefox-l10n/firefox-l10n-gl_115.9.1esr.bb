# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92d5e29e522a9ee697a74009bb9d0ea5"
SRC_URI[sha256sum] = "287decbe948f48824a776cf544eae82566a55028d85fe5baedfc15ddc4ae49a2"
