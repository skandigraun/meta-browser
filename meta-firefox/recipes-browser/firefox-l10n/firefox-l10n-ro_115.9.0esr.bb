# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28182f2a8445d8a4d0b7c3aabd37be9c"
SRC_URI[sha256sum] = "d37dad5ff28973e1bd6e209005427aa38a77f0826e95e8237f6d5d57367ff325"
