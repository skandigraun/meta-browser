# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc75f962b509f25dee667c0b3c3f8a89"
SRC_URI[sha256sum] = "5e547a87d576e7fe797716585f5dc8aceae1faabcdf43c7b11ea62dd58a9bfd9"
