# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22074f16a07ca4a820963f9afd69cd40"
SRC_URI[sha256sum] = "ea41ab5516de84d9c965f9c2c972a4b7d62638fa31faa7f884b6934a5af3135a"
