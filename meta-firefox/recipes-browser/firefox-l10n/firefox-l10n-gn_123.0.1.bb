# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fa88fc7c74c7e314da256c210b2dad5"
SRC_URI[sha256sum] = "fd8337411f87372977a37f67e03fab9faa5bcda029f47465eda874e8214e5025"
