# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "259f82ca572bb3f20114f739b276af39"
SRC_URI[sha256sum] = "a8e7b65154225e9fdd76ceae702d2fb79a6b455ef0746d484e44581311250f99"
