# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83e3b080a757166e871ad3038db4bc29"
SRC_URI[sha256sum] = "01d298a6c59d454161fda1a8f1133436010fcab39a597a958d04000c8ae7108d"
