# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec1f110bb4c84ba0013dfd21a3e49295"
SRC_URI[sha256sum] = "f9bb739dc5c322b26ed3c94b02416dc1ca487c23ef81cae327009b37adfc4f59"
