# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87bc988a93e773d5c731ec870ac999d4"
SRC_URI[sha256sum] = "0135c35877883d749c79e5cce92c04c0d2725e81ed11638400f783e106d07752"
