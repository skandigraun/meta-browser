# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d50f67cb436d466f27dacd458f48594e"
SRC_URI[sha256sum] = "fc95e0e593fd1f011e8987381d4af33571412ee01efda284d69f9ba26f4fd097"
