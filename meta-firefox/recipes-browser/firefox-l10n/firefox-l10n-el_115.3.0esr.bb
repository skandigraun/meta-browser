# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73fb7159d25fdbb87aa756e0f480152b"
SRC_URI[sha256sum] = "e60908c3ec06d4fcd3e9ab3c7bb62c19d3980d11c97d143af2cba1871c2be2ae"
