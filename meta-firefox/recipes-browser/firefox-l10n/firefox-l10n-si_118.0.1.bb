# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5533fde6d2bf293c9f62a992efef9397"
SRC_URI[sha256sum] = "7ed33320b7992347e03a3528b821348304fa9d97f4bd288577553d913ee57661"
