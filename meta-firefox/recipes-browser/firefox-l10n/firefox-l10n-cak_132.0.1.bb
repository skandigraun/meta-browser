# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90acd37867f6fb44edf876b92495e511"
SRC_URI[sha256sum] = "881039c5ce1ae3b2aee32b93428e6c69999c206623a91bc0d7a6c5ed2c35fae7"
