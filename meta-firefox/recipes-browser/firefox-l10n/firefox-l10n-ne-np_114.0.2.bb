# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d14caa93df842df784be1a0b194c5da"
SRC_URI[sha256sum] = "eaf547927294732f574a9cc34b1e3269e68cf50b015a3c6dc7ff650838862c09"
