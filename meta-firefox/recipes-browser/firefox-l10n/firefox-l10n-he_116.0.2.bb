# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29e4fcbeddb92e0c98813053a68ea3c1"
SRC_URI[sha256sum] = "2aa53b7ad00fbd04df485aded203129fb5e2ef24c298290bd0a2d71e9e04ed78"
