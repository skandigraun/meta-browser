# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9192a28e961d91accca18facfa3048d"
SRC_URI[sha256sum] = "58f2f74b89a32be00b9343626de69100b5f6bcb9b064a22726d9526bf0aef259"
