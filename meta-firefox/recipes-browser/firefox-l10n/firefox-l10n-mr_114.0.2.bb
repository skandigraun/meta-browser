# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "34c79d9f1ae36758ce3104e2b2aea664"
SRC_URI[sha256sum] = "68160c5ab0170564617b4cef392dc769495e82f06355945cc968a7eeb9823bea"
