# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c9f21de1f957340730182362c7d19b9"
SRC_URI[sha256sum] = "bcb553fbbca8255155a8ce4c9b1148ef8fe0093bc954b525d8b8ab82db09730a"
