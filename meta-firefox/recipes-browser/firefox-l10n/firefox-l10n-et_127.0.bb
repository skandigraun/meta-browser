# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e2da229cbf2e8a8e69d05089f4d71dde"
SRC_URI[sha256sum] = "1e8c1cdd7c107d6b748500bea10aca0691651853bb0c795590f82e087df0de19"
