# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73357f4a86bc00762fcd29ae65528d39"
SRC_URI[sha256sum] = "e003703fa42170c5774fe222a4f93d8e1862c16a64743d4e5a8d26e4f94b63a0"
