# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2aa124a7a5e7415f5d811fe12765e575"
SRC_URI[sha256sum] = "0ee6e67137d0d7bfe8f79678683ce99c8205c87893da4e2e0b0ee2fde3016ec6"
