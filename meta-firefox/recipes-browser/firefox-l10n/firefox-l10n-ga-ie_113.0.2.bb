# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d269872688296f134a3d02b9f9d7cc6d"
SRC_URI[sha256sum] = "0114e2bb5aeca785256df41b9b21c57ffb88c6b99e866ebae1adf8de31079b7c"
