# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bb2d8263d1f588afcdd13db61d2a8330"
SRC_URI[sha256sum] = "4d3365f36ca13d07ad52194a3d737e9a2705f1936721b48d928528db7cfc8ecb"
