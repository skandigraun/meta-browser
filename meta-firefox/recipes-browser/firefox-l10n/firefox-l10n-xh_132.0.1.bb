# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b58564c4d0cd63a4e03a153ef976ff2"
SRC_URI[sha256sum] = "73dcc7d4f1668c8299c233e71e4c6bf4f647fa2080efc231e26c365eafbea798"
