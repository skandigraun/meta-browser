# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "486e5823878861b124d1cc72d12b7da3"
SRC_URI[sha256sum] = "379119ca5d80c54a25a7871c87256becc6a59946633ca0e6b293b5eea1272406"
