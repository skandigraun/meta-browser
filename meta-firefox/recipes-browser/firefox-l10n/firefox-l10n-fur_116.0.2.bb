# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "857e4afa28a56657a88bef58fd2f9797"
SRC_URI[sha256sum] = "8ab2597275b086f43f3e855f44732ed61ab36d497df61a5bbf76b8e51a71d156"
