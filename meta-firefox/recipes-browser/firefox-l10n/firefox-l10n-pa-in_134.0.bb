# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4576dcca302ff87b3818edc64c9aea4"
SRC_URI[sha256sum] = "3b8ffe651a59e330760564cfa78d3df52b066c0db21dd7d1253e3386953a52b5"
