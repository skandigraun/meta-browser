# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82af131777b4015952ecde6b12e9b2b3"
SRC_URI[sha256sum] = "c4133440283fc1c2fffd242d3753f4addcf02dce69256f21b1784283b2bc92c5"
