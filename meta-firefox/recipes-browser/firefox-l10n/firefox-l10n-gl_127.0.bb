# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74c7cf897941aeb60a46820f2247226c"
SRC_URI[sha256sum] = "e10241d803bffbe7fd8957e918b83b15b22995029ff28c47dcf70c362dbe5c26"
