# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20e479dac392f8cc90a99b9a37b29074"
SRC_URI[sha256sum] = "6a388cd019348ddf1b391e5a002a5a69f6b57b126ed7ef2ebb0363d3394d79c1"
