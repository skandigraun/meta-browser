# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "021896218ee4f60903e44e56df39aa61"
SRC_URI[sha256sum] = "a15af804d90c7da97e736919351742919c3a1b9aa882b131001d199ad6bd1321"
