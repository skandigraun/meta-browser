# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c0ba3e6e40a415532d1e5730793dc4d"
SRC_URI[sha256sum] = "ee85c337dfc01fb91a9d5f7032a55b788b6eb453dd5fefc7c9a51e9942620585"
