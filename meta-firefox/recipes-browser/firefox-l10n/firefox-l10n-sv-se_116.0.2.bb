# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fa9c13bafd4ccc2d9322665343b6800"
SRC_URI[sha256sum] = "8125795eb5586ca4289c0d13921151a9f7e12f0c982994494a6a42e8a7fcd550"
