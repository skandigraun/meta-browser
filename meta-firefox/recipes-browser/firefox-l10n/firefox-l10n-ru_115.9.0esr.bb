# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92c4662294c977ea6705d356e5e3d525"
SRC_URI[sha256sum] = "7f8f21a47f22e67653d7e204098f3a830fa1728b1268ab599af5bb3a2421d8af"
