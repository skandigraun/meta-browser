# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2dff521816a9c30fd9bd3d81ba235c4c"
SRC_URI[sha256sum] = "d935927a11810620b7032b94e82107c335aea8c991ae184992aeeab2db1b7a40"
