# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2cdebaa9b48cca201526e72ae5c81d95"
SRC_URI[sha256sum] = "05583a8ab88ca08643c966f094152e314f18d9d982999ab58fb7f109a3f761c5"
