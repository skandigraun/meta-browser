# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ff562a1f0bdc4a1735497e49e0042a5"
SRC_URI[sha256sum] = "d7face7446325ef9b31eadf19d73d3596496e359d5aa8055b10fc85a872bbfd5"
