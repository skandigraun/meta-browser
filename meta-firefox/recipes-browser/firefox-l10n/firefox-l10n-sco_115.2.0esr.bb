# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a247efc389e0a9eb5485c9e0ad05fbc9"
SRC_URI[sha256sum] = "c7029c26993315c2a76c8f464dfb59eacb4e01750357573ec8942d6e79b368db"
