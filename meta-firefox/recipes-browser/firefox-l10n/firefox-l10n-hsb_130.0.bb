# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ed8d17ea902a5032f6a639844d36818"
SRC_URI[sha256sum] = "362aedb4f896c648cea6db7fb5d372ee96bcaeb0c0e573ec89523a54d4176a02"
