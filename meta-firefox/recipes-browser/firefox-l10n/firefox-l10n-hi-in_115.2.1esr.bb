# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b16436e14556bec5671af016bc6d47a1"
SRC_URI[sha256sum] = "53f4859625a6239f37128fe9699ae59d8173a8c866441f6dd6233453aa61f1bd"
