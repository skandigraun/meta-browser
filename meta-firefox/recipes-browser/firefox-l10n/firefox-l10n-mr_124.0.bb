# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e078c10d464192e3ed792cd47af0a8d8"
SRC_URI[sha256sum] = "c5606a6884fe025cae9ce37cb6aabcddb0d1fc42fb6036134f8c9743dcd015a9"
