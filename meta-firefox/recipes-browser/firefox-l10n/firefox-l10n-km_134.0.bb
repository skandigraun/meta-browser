# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "82c688a1f4504be25eca56a566270ec5"
SRC_URI[sha256sum] = "6be86f370a9ef341a7e83d737db546ca899c4b94bb1d5f26b3b73ea53ff7e650"
