# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4a070948adb9d152109d40d6e0e7c494"
SRC_URI[sha256sum] = "7d89b13b169b5199a93ce474dd31651f3bb6f0ecbbfb105346516d13f6e25e60"
