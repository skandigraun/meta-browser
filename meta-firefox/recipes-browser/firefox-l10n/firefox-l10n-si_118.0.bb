# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a231fea319d4e30ed050cf9f2d37ae91"
SRC_URI[sha256sum] = "acb75376c841a8adb732928398135a017d9d873f35722dc311c994323386f2da"
