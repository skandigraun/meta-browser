# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75b8a07f92e941676098e530f20c1e4c"
SRC_URI[sha256sum] = "2fc902d89df93e67977fcdbbb81dd8a7b372d96a5b099bcf1a0c7daca512669d"
