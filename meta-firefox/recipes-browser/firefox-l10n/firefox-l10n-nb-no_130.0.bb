# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0b383f325b561b239af839e51d93975"
SRC_URI[sha256sum] = "0b16a2a65f87dea6034d53489d260f4b0d32210969469a1a24616ef791e2e15d"
