# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe4142b68998c18fcb95dc0fcea68ab2"
SRC_URI[sha256sum] = "a4296aef7364b552874f8cc69ac480016b6e086cc7d0bb3bed2b9535fd2b3e21"
