# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc9dd6dc08250e1bbc847442d7a54fce"
SRC_URI[sha256sum] = "396da79566573608a9e14aabbab1eda1cfc69ae7ddd143566196a1ffed6c021d"
