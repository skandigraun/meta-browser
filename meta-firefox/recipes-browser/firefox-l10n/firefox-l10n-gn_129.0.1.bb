# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3cb44b85230060d65c18197ec1f0b18"
SRC_URI[sha256sum] = "41017dd635dc5445085acd1171f751d6e3eafc7fbb76359619b1524bbe6e8bdc"
