# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1fae03b250dac5353c94f0c36288524"
SRC_URI[sha256sum] = "efa1e0fad65599488b63ed88d7f629c7fd9796b9d1ba69556b066cc37adce0ae"
