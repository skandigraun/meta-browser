# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc447179647f60eb4c286c92f0c03c39"
SRC_URI[sha256sum] = "566b4635943d3e958431f421afdf94c2c890889b1004629a85f79c19055fb88e"
