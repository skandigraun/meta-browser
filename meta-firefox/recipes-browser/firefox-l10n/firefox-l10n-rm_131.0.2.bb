# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dc1893ef98085573d8b8ee54c2f8d27"
SRC_URI[sha256sum] = "f03f2c283e747a4ab6d9430f93ad14f19601a57726e0d5c4a15b034d9a990adc"
