# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef4b66942d51f634662a1afc2712063c"
SRC_URI[sha256sum] = "cfa4ac837a90f7cc8512b539b3ed12a76e431bd6c35835f5fcc412c42777a400"
