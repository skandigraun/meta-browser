# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "89e416d6e5a3e378e4dfd29c458ba297"
SRC_URI[sha256sum] = "df110d489ea22762708c5818ad8b348524ad092b3f7e8c95fa2f5831defe9dc0"
