# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7f9a946671243be0e6ef93c4019b6c3"
SRC_URI[sha256sum] = "b8e1a9293476e617f79b496b3b15e5d554c449546f4403714083e4450a33c4ec"
