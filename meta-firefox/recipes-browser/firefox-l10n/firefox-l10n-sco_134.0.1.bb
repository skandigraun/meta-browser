# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c28bf0208c7e5d05f1beb5fe695f4a56"
SRC_URI[sha256sum] = "43ffa4c6034bc454a81a9021426bbd3f4971b1dca081922683fc2f0171fd5027"
