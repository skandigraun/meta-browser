# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9573e931254d68ed93aa2d81595e8166"
SRC_URI[sha256sum] = "2b9311d1c07ccf67f8ff0fa87dfa102a61092058a569c8ff07f3cbbebb925d0c"
