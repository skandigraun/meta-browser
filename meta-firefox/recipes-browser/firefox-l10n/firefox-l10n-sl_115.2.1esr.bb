# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5f9ef9cc154420dab35001df74c43d2"
SRC_URI[sha256sum] = "7f9f81f83867cfd3204ced274b195757b20672684f3e4ae1cbdcfe55955bbf89"
