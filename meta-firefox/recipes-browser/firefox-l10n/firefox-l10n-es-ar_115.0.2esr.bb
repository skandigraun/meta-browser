# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b8700c8c0e83c06315d1ada9251da8b"
SRC_URI[sha256sum] = "c845879072bcde78ad19c862c8754c86a9a8b2eb8a6c4e871393fe1446bccf46"
