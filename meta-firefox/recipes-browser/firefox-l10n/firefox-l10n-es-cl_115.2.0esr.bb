# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d301f5f8b355daed3d677a2cc532d7b8"
SRC_URI[sha256sum] = "dff702c66ce34f67ff786f3aed6c3a01fa4f2344bc6b964a7bb87d6c212269f2"
