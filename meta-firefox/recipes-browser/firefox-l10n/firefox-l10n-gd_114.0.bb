# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a82f5251d0efd19f1ee31fd67cca9ad"
SRC_URI[sha256sum] = "48d5d27014991eebd2f3cd86ddce13807753fba0c67af32f4665db3685b45ee0"
