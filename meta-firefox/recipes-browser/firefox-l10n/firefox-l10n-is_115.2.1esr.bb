# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "454dae4338cb90c57cb1bfea2594e6cb"
SRC_URI[sha256sum] = "d2d2f897bc0522a9ce7089f8f5969c1c91e93a45c0cef8ea4f04188af3bdeeb8"
