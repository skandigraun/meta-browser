# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eab170847cee3b25e14562e0f9f2de3"
SRC_URI[sha256sum] = "e270da4fd12ff00118a242ccf85cc731373749e4ac7abb27ac2a01503fe067f7"
