# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf75ec393da30b01d925a7e896a94ce6"
SRC_URI[sha256sum] = "ed60157c7927a4ca6cf201665d1186adb313f5758bf68917f6492106c716a9fe"
