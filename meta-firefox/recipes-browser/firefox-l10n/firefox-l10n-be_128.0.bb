# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a22b79774c7d3498949352d06c6655"
SRC_URI[sha256sum] = "167cdf3fc85751c2489cdc484f670a9a2c1a0f6c680b64f8bcd29ed9597fc240"
