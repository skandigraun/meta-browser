# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10395c7395aef20091bced65a7725b0f"
SRC_URI[sha256sum] = "35e5ed0062f8d3a256c71822cabef7c423cae424f72685f9db35900d8f2306f7"
