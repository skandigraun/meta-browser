# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0a1d943f42134cb3ebdf3fb16a8f9db"
SRC_URI[sha256sum] = "89a2e43c003fa651d5abe5592c8d3927b93a36ad4463eab75d3bfbf08f5bb836"
