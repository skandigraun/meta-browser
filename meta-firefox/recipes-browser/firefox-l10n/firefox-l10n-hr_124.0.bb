# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7fe9100e8c502dc6235c706c1dc6405a"
SRC_URI[sha256sum] = "b6ae2da544496b8de3b7b743077a64c1b0c5958f21189122bc862965c900edcb"
