# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7600e25462687fb2eddb910e07d3e9ba"
SRC_URI[sha256sum] = "cd44a6da297fbf021662f5aafb580333f11072e0165ec28c1417435c41717fbb"
