# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e283bbb9b96b612701bd98322fa05f25"
SRC_URI[sha256sum] = "f441b46cd64f80e2e1a1021290725c259e090ef6b5c596259d562afb9b479687"
