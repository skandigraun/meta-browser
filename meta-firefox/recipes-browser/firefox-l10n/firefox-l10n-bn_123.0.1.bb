# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f3adefc8cea555869839efbdbbdf941"
SRC_URI[sha256sum] = "8e5a00411cf6a3790775cbb711070bb984bcee0a50118fa48dff16e6e0ddfb9a"
