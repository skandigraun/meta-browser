# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "69c5ee6a007f554121b48538c901c054"
SRC_URI[sha256sum] = "2bf704e06f5b176e6c5768e52328fb429c372ed5a42810132600a8d6e701fdff"
