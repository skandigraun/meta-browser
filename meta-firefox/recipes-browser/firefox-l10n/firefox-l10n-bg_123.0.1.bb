# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fc3fb7c43b694de580a65d14891f089"
SRC_URI[sha256sum] = "7ec20f9969ec5f19c2d68115b1d4fcac2c442f3e256659e1035051c12ac31eb7"
