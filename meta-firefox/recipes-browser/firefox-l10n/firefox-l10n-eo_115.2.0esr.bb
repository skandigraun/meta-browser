# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c2cc6277bedbe4fb7f0e970a24552e3"
SRC_URI[sha256sum] = "bf0456c829a17e661342ffd17814f4083ac2d0610cc833e92219ac4f80ab176e"
