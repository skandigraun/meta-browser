# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "40bca25f58fd14658548cfb4c5fcf4ec"
SRC_URI[sha256sum] = "0711ac5016f206bd807a69a93f957897a124547bf9ee30aea8be26a2e9ff249d"
