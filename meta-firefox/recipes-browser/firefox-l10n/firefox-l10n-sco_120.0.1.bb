# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4cf6446b21dae61797a5b9c730793dd"
SRC_URI[sha256sum] = "adfff5cc6cb150c660dcee41411e3095d1e9d62b2ddbc01653b7ca31f1b585b4"
