# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a08aba496a5e38396783b62fce893dbe"
SRC_URI[sha256sum] = "f257d32d71094caff9252bf86a2394b36406c5f1bae9e28eb6cc8d7a16e75471"
