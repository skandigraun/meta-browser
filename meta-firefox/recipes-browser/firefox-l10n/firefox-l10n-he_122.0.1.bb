# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6217e4dbaadac430f6173805e13b3b93"
SRC_URI[sha256sum] = "59e652913bb2b6fcb7f3684d9b9895b565250442ded2f953f9f697ca83668c0f"
