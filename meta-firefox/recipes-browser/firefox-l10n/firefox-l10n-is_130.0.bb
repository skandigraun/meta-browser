# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9eeb9d845a84430873074985d2856d07"
SRC_URI[sha256sum] = "73ec105fda71c0549cfcb20a74bfc8f603a397ed2a8fc1eef71f3840d354b16c"
