# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2d4db6718605c22b4b7ca992593ccaf6"
SRC_URI[sha256sum] = "89fcba4458bcb89b6486c739a7da6ebbdd8dcb27dac03c31fbe9af42836e0846"
