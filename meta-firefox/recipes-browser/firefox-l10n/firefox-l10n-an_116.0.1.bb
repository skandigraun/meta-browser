# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e4e57c77de41f955e04d8e9d884f074"
SRC_URI[sha256sum] = "0458aa30fb09a2a7ae8c0433940eb23c6ab9be216c34e9d6de8a15809d123b91"
