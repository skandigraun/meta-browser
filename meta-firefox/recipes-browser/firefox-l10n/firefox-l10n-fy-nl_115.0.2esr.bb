# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71df274acfe3a1f4dfc6351f3adc3601"
SRC_URI[sha256sum] = "88a35de5f0580275811c75396a5a9b08c8c7606ccd99ca727dc4258490960a99"
