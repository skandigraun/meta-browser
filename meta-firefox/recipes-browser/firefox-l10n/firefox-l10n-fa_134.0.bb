# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c33cd65eaf86d95b54b6f7cecca082f1"
SRC_URI[sha256sum] = "d6e0d9f185c391d3f608d07f627052f7274d1a05f0a18eea1b9d5eab7429bd52"
