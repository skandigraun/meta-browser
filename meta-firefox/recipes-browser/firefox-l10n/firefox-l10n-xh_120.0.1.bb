# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "937dace48c9cfde1bf81e28118a46a36"
SRC_URI[sha256sum] = "f1684f162311f7bc3287d2d72ab7b1fdb18a2086ce2512def6f20a5e0b49737d"
