# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8ae2b1b17b26a9154ae8a06b873a724"
SRC_URI[sha256sum] = "1120153727485be128d092e176a553146633f52b5ccefe33988a4b83ca3c23c3"
