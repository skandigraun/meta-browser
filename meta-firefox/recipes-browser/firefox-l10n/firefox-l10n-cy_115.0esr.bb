# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da78a9d84c59329b5a443abbb0fa955f"
SRC_URI[sha256sum] = "ab8126d6c26154a855c3bb64e4963ca85c6760a7baf5a0a456106bdaa3f0262b"
