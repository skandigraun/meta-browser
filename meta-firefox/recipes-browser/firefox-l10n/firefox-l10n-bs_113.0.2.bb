# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "608e11ab42f678073d23cd10e8bd1c9f"
SRC_URI[sha256sum] = "efe6348ebefde040d5ea6cdd5c38680e66fbe02bc401c7de7a871d9ad5ec1da1"
