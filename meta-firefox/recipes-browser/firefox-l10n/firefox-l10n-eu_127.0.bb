# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5ac7d9ba34fbf7a4af8b6c3056c01a9"
SRC_URI[sha256sum] = "06d6c3086948d34641b7f6faf40f357355bd3c38feb52bad5118c8d67d96337c"
