# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8445dd4d5ecbf02dc70f36b4547066ee"
SRC_URI[sha256sum] = "3751440dde95819c51e00556fe6b85fd1e5bbda6e526cc9735df163ecc21d8e4"
