# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d99cc98bc6cadac7961e72963c13ab4d"
SRC_URI[sha256sum] = "90f17853742ea99dd95870046b6061c601edc76f9b4f82a7ac6b42af0d3dfe07"
