# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc5fcbddac56ece7468efc1ba2cc0012"
SRC_URI[sha256sum] = "34af0d2c4564192c53aba42c9879743a7ec75b7125cf8bf24a4456f88dfb51f7"
