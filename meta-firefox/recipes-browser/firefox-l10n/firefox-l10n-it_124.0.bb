# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17becf0e19b59a5ebc879bc195388677"
SRC_URI[sha256sum] = "443436fbe80d8f7da55d66c05134a7c4ebaedeb6b0b79f050d78a27adb02cc53"
