# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0efffb3e38d36fe3d4092cdc865d41df"
SRC_URI[sha256sum] = "4763b5608ad6681ffa11507b91c7ccf1d06089b2a084478f65bf11318cce0be8"
