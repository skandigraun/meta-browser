# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "781a6249f554445619dab2e165ce565f"
SRC_URI[sha256sum] = "8b1348b38f349318f3099c755c2342f2483835ac1a6eaee63908a2f91b2fd6ec"
