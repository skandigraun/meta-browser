# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1ec72cfc928653aeb252063bbb644b0"
SRC_URI[sha256sum] = "9e49e10848a53d0cf56c74d2afacc70af01fc8cf07b42d9e1e7fc74ca9a83050"
