# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d21c11ff155e3a4ce60870230916a9cf"
SRC_URI[sha256sum] = "24a1f7e2169c6d6fdddaee9b6635f884b1c901896386f3e00d632e0620fc64bf"
