# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4abefd0e6ef86715c60130959090ed7a"
SRC_URI[sha256sum] = "05e3b2ae594d9cc5efcf7b3655efbfebcd6a34c84a4cf5287e7aeb2eae349508"
