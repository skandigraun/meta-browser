# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e89068127369b16568eabe1c31fb7a76"
SRC_URI[sha256sum] = "312a716290509a7d3814665fd00f51891d00b38741c5663f8cb0dbc357d8a977"
