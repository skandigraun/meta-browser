# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3a75c800eb02e6ac7c7133ef7f775b0"
SRC_URI[sha256sum] = "9ca61c34c896663cc738aa880ba3babe9ffe2799b5242299fb6a244da70d5c55"
