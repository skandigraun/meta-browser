# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80a400ed504dc6140feee24a2f190037"
SRC_URI[sha256sum] = "1e8c88abc21ed3a618cc1696d77b9a582d4b0c2d7df941cedd1f1369f0a563fe"
