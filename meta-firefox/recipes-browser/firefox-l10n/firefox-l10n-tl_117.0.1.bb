# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "df426c62a86cf7b32a6a1aa4848635cc"
SRC_URI[sha256sum] = "9b28a5741d8a6bd7c11300663773115f4448af992053224e66a86b00b491e6f1"
