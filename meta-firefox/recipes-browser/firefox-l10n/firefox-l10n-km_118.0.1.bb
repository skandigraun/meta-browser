# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6753a410b0786922a8faf4f5c8d12c96"
SRC_URI[sha256sum] = "1da914f81561b47bf2c130aa918d2f011429f6400dbd0bcb0e2fa934ef28c212"
