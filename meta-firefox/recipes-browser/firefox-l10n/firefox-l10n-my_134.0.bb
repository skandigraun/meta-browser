# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92cb69f39b104c6be92d6d4b9d4fbe74"
SRC_URI[sha256sum] = "e151f4762cf679492577e4f59b906f30907273aadb1d679da514448c0d2fe52a"
