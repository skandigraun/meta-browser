# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db41247020dc2cd43402dc99a2dfe51f"
SRC_URI[sha256sum] = "bbe930281cd7f90385adfb81859c70f2a10f673d0ed80f3a0ea70eb38cd4c4be"
