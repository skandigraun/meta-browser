# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35f64a4faaf4721032ce59eb62fdbf7e"
SRC_URI[sha256sum] = "4e7634a6e434586587178193d8de348bc5424ec734ce075d01452379fc078d38"
