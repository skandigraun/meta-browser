# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5846f3792366406461b17fcad29234b9"
SRC_URI[sha256sum] = "7e810949a90bfd12c1959877bfa0b27fccc352197d8d137228ffca32772d9d7e"
