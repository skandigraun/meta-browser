# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a69d78cbd039ff53aff0330ee1a5c1b4"
SRC_URI[sha256sum] = "390d4a3bd64aa6ccdec24cf275df6c623f68980747fccbe49e2d63d7e7db2de2"
