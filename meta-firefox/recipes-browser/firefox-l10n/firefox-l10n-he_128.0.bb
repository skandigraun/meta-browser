# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "01c320611ca3d7a41e6cadcf083ba17f"
SRC_URI[sha256sum] = "3f853c7d9b45f26fd744785e5e1a445b9b58bcce00dc455fefced0f9fd65081d"
