# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43882863bac4f0de97e55f4834d5285b"
SRC_URI[sha256sum] = "8a2995da384dd920a0aadb46f424dd8d5630a1d18c009721d27dc4d3e859b7dc"
