# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ae2bc32d34a8cffff10ae06c409ed7"
SRC_URI[sha256sum] = "1d0c2fc91dfc8b1041ca3254548439602f634bce30da63f1a94836fcf6f5891c"
