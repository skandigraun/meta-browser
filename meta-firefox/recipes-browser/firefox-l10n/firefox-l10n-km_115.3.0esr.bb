# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "092a7621b480f7fa37d784ed65d53965"
SRC_URI[sha256sum] = "732b7d044bd718ff7c1adda3baa8ac95e9a30eee0a63907d1be2b49c1e909858"
