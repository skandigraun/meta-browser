# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4e708ab6851435ea087ab3a8d7d9a69"
SRC_URI[sha256sum] = "04c562bf35377fb44f0e8d71bc2ca6ef1018a9144588dd30d68ad632c6568fd4"
