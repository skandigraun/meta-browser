# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12a9aa57c7b4299b6a28d3207195d7e3"
SRC_URI[sha256sum] = "96592a74d16993e03fd202be691f2e3bc9ac6e2d9fa50a6de0670f46e71b203b"
