# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c6a1198635354beb584e7865efed8fa"
SRC_URI[sha256sum] = "4832f580f7f90fc82438cbd2652d0958e105a67648bbe8ac747a2c303848167d"
