# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb6124812b0a5339db4c46e7ce8a96ce"
SRC_URI[sha256sum] = "da0e4e3abc51b101e84450ef84f77b3709ef21d7db3f401f4449fab69966ff62"
