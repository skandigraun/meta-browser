# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "50865f76b12119836c7b2608598b596d"
SRC_URI[sha256sum] = "686539b24fa6bd2098ef16cb6f3970f2f9e162cd46dca540a31abc3ccf76ff44"
