# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95b1256b7c0c57ecda0483560ce2ce04"
SRC_URI[sha256sum] = "d857d1d7c125680e5faf6a8e59e7b96e23ad9365baea456af0932457dddcae92"
