# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "135b8661ee44ed51595c564c903e9802"
SRC_URI[sha256sum] = "186c0fe35f6fa04f434146861160ab40024603152592c0bbc15958e2efd7ad5c"
