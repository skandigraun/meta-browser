# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "191b38705fc3330ed61e6dfe9099cfed"
SRC_URI[sha256sum] = "99d6e93111ac12229b7d6cf212e3fd2186080bd7b9b907b00d0988b749aadc57"
