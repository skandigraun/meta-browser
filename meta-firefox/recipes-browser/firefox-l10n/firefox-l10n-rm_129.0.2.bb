# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "809b9c23cb2665331ae5809d67de9511"
SRC_URI[sha256sum] = "cab6576e3d6ce08dfc16c7ec3673024e599cdd2b11f85dbd10580f8e1623573c"
