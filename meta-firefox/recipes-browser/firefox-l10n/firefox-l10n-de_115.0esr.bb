# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efd6183fa9a3952c8215e9d2fd4539a2"
SRC_URI[sha256sum] = "a68d6af91e25fb4eeec53a36df8c3b47f54cb2ebce21e29558e600b838a17ac2"
