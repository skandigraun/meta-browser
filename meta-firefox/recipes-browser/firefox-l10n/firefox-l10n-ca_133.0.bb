# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8a482e03d461676605f8831e1df2e8a9"
SRC_URI[sha256sum] = "00757d9107812ddfb0793fd70e7cc3622676746723213d3a9934113a6ef2b9ae"
