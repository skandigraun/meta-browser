# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "28220fd3e026f7e6b5e15bfb5e3fd606"
SRC_URI[sha256sum] = "152fbc9351ccec1ec71d5a42b45805849328669b40f4ae46e07e2d0180735d39"
