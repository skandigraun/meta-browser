# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ee9f426728f6933be623b08ecd4ac5d"
SRC_URI[sha256sum] = "0d740df69d989342961874c558d47c145fb80ccd2f9512f8928f61bae6c20c5e"
