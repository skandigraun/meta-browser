# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0312c268409d736e6ed05b576e10f101"
SRC_URI[sha256sum] = "ab808312a1f71204906e2cb7964d1396bbbec91b654d18847946d981173d29be"
