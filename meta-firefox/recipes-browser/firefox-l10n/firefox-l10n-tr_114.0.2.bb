# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f38a53d19c43740c3c27bf41a71cd3ff"
SRC_URI[sha256sum] = "9d1f1b436d0d33d543de838624d8e5ca66fdbb7dab3364d1301daf600b9143d9"
