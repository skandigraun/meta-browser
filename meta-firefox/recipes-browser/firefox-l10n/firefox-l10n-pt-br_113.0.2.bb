# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b6dce1adc62751dfb5e1f060b2ce123a"
SRC_URI[sha256sum] = "9556019cdf953a6eb44c2b50cec060d0ff9fcc03870ddbe5043f052ace4c7def"
