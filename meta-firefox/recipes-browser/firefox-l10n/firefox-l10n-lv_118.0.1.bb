# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "865447ef640f0428001a7a6aecc589f9"
SRC_URI[sha256sum] = "482903788e66ac29d63c416f5223afd398883a7eef516995480f8d4caf138397"
