# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bb266ae5ed60dbddcef291e70b6cf3f"
SRC_URI[sha256sum] = "e577a3295bc43a0b292da7aff917d3d5f63ff1f99e58a89dd03fe62d0afe9c9c"
