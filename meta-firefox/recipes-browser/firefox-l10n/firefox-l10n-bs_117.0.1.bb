# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e6259bf5dcfdede04e0fc2971081f0a0"
SRC_URI[sha256sum] = "c9697c335d5ef583e609b9327d944da0e652c74502d200a619ce342e5e6e652c"
