# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63a9a4410d64a695a88cbe1d483216a7"
SRC_URI[sha256sum] = "088aa227db97c83358f4495cbf947b8e68d7313f3d9c334e5ae63a548a617e17"
