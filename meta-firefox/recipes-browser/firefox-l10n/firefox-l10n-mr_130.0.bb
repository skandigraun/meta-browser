# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a183be71f4c462a351573f386bbf96a"
SRC_URI[sha256sum] = "5bac43f08638fd4d6063ba0bb25eb6c647994855b1bbec1061f20c7713018721"
