# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15f036f56859b477c455f9d57065ab89"
SRC_URI[sha256sum] = "2c1f58c4f2de128c2e56d359d438eb5e1ef0b5ba7cdc64d61d2e0f85825247f1"
