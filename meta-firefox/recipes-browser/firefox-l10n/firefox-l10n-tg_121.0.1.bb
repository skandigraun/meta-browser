# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2e103c319e80abbd62d6164942160184"
SRC_URI[sha256sum] = "1a225349f50608168127d583cd8eec81e1dd1dc5f6bbfa75a585dab98e482082"
