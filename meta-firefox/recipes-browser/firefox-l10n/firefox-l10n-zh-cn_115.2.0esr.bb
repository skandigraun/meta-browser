# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "944eb564df118476c941e21adc9a2096"
SRC_URI[sha256sum] = "70644fa53fcc1db31b154c45e4f445252909daa163a428df883f105a11048da3"
