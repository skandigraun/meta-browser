# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0fc43c2aece0ce2e27c23d98de24abd"
SRC_URI[sha256sum] = "603b096e7aad7233929fa74c7c342d31ac22b2ea27aef8c59a4bb5774f7eba72"
