# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73d8c01b2b04be1f26afabfa6621f9ee"
SRC_URI[sha256sum] = "508f7867e5a935ea65045f8889c7a41d2c830dd6480420caca6d3a1cdaf9e50b"
