# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f9ca2bf6450e086a0fbaaf4cafdb9f6"
SRC_URI[sha256sum] = "d80d910e3851312d1c378fb9919c9fdfaab4f87654122ee778c8df76a11962f5"
