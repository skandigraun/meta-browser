# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed51dce5e44f149e4974654f2cab97f3"
SRC_URI[sha256sum] = "ee1ffcf1b3d2657171402afd3405d64096ff5dc31b4e9b5a4254f3e64d5d2721"
