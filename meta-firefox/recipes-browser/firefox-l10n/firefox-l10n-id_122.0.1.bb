# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6761307052e9d3d3ed3a9b536f809441"
SRC_URI[sha256sum] = "09664f3925b1cdfade757b7f31aa8e9a1551e84be31fb666966d4f7d6eb6def2"
