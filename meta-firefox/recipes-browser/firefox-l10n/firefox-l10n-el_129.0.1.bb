# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80cbb54176c3d8ffcf21368a81b2392b"
SRC_URI[sha256sum] = "d793ae7283c62b078ecb0033fd20557f205d06d2d25cb40790c6ba7b38d63fac"
