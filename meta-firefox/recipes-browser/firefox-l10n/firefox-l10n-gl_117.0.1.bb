# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04ac76ecf9ce775cf6bc93f256e23ac0"
SRC_URI[sha256sum] = "d546b0d6350f632480f4e6cb91c8fca34382c4cbcbdf38f5ec7bc4057f211f5f"
