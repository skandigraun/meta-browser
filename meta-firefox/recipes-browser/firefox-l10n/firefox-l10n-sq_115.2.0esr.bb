# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ec061712d9f4df58da55f174112dd715"
SRC_URI[sha256sum] = "280241e045e38dc6ce45f1166837bebdf38a7a5a8da893ebc20cc1e3cd787402"
