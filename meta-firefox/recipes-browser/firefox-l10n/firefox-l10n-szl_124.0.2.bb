# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb873b31712b0dd31e9a2a4df0ed12fd"
SRC_URI[sha256sum] = "92c8bddd0c10ac873fa8242e4c5a1be76fdfe8dcc74446a4606cf3d34edf5120"
