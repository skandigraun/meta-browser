# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53f35ba8f4e6e23a8b2a508ab94cc1c9"
SRC_URI[sha256sum] = "8d9debb2f84fecd9ee51754af3e13848f37da463e19060d6f86931b671071423"
