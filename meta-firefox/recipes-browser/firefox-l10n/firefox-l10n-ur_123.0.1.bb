# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a81cd3bd4de2426a281ae8903ad0d27"
SRC_URI[sha256sum] = "ffb4d922ce426772e7389b9d6cd94c24400212f0bc49000bdcd5ff4158218d6a"
