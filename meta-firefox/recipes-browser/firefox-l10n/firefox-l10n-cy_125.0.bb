# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d30bf257a9202cc0a80be7f7813d64c0"
SRC_URI[sha256sum] = "2392a898733545e9cd63bae5247e7d8034d1c625d4b4aa2d482d8fc560c252c9"
