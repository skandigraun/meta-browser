# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "71a6cc4a532fad16fc355151705be792"
SRC_URI[sha256sum] = "3bb8bb71550a23bed424e279bc53a8c792d1a683e9f744a559308d7e9f5aee70"
