# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f265e0bcf6641fa1209422d6e34bcd9e"
SRC_URI[sha256sum] = "9b76e04fe1d3a170c22d50d6afb871fbc64d54c31f96a6f84eb189f0b1fd6524"
