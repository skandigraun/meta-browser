# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02b684aad0a4283ad464c62720fe31d0"
SRC_URI[sha256sum] = "08dc01defd8e234ab56ee2f31622963d002967ade1b42b964ece6854cd6901d6"
