# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1330f7c2a03e52d48e5c1a231432dd06"
SRC_URI[sha256sum] = "a3cc57784bdb794c44978c7b83a737a125b3e855ef69c709d6a84f3618f5d4f0"
