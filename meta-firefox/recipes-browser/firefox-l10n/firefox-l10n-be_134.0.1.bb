# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8177169ac70ea06b7ced718543d0c96e"
SRC_URI[sha256sum] = "acb693227fef817a82983862d7fb85f0dc683a1c5081a7f12b344c4160f3a54d"
