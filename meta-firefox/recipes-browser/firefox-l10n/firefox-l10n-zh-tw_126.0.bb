# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593f219a771f3152656b35a365a35f5f"
SRC_URI[sha256sum] = "25297464d20aabddc747c10ee94f5d2d9d801861fcf001b17c8fcdb6abc0b922"
