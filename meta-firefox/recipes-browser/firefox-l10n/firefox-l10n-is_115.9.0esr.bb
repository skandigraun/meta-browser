# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3638f53ff8fed60b7cae8f4dafbc179e"
SRC_URI[sha256sum] = "c7806ae23aa4ce0a6e933228339d41d1c5ff3ed2890331ab61b3fce60bdf70ad"
