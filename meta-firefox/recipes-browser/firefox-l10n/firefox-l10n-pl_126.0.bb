# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc117f4f658727399b2dbd971002504c"
SRC_URI[sha256sum] = "3f895f01d3a3a4e9618f421ebed62d020dfdcbe0f593cc5a62847071cb1f9d00"
