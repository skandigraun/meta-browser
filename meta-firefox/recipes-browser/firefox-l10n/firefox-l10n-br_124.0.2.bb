# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "621d00e09cc12e9f21719b143684507f"
SRC_URI[sha256sum] = "a4646d6b888c834078c9b56d4869358b59f6aba7856a0e5e06c1d10f6402a94a"
