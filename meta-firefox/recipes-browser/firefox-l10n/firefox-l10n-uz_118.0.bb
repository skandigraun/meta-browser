# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27a73d36427a43ead1c74160c9dfafb2"
SRC_URI[sha256sum] = "ce3b2d63d29beb0c0e3fc02520be54560b80527af3a3f12bdec490c703179a1c"
