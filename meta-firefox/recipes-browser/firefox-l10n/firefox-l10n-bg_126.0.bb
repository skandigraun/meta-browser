# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c4837eebc4b879cf237d6f0f7ba8280"
SRC_URI[sha256sum] = "c04a3244047f9c807a1d81a6fd08b5fd2d19bfe593f80ae7a8ba21b7b1d677b6"
