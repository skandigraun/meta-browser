# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60412f5bd8e7bda6d1ef3423a389e11b"
SRC_URI[sha256sum] = "5455508e3728c06942eb4d8cab9d719cddacf6174c958c136ea58031b782d347"
