# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d8d9e054b7d09f99fa68ae52cebd5bd1"
SRC_URI[sha256sum] = "50235cfcb5ce2b1d98b03f05de43ebb4bffff40cf24e46f91ea91ac3cc424792"
