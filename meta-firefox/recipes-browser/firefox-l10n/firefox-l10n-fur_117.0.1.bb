# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca9bb1229b67866c9d6e64e36e2078e4"
SRC_URI[sha256sum] = "bd0ac9564a28923a800c16ea2d4cc46a104a79ffef5436857d11ccedbe27c445"
