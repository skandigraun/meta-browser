# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52465112aca7f280a053a226a1b760ac"
SRC_URI[sha256sum] = "74f16530509731f3c7f282e3cfe3dd3c566c7187b59227e6c6e5088d2435a1f7"
