# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "deebe2ddc719637a4e00f6e304b2ebef"
SRC_URI[sha256sum] = "71d57e233313b02c0ac72424209315c841323570015512215a083837d2f7a203"
