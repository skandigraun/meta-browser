# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "04140161dcd6e53d86a003f10543b512"
SRC_URI[sha256sum] = "601974b0104de76ff1564aba34910465ff419e76c986a7d6931ccc0049632964"
