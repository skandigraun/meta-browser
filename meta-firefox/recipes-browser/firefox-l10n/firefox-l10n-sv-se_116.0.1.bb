# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed52035df5860fe004f6d9faeb9a6395"
SRC_URI[sha256sum] = "96a959fd3494a3ef34128aa2240bd66ea343aadb93f709271640f33ba678b3b2"
