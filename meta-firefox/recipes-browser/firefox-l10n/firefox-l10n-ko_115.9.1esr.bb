# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33b927f674f7fb4bea217c0139d0c7fa"
SRC_URI[sha256sum] = "cb6bc930f6ae13d8c4ba54647b2528044b6dd34d1f53eebceb9786bc54f60f06"
