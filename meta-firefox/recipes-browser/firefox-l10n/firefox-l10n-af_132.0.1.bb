# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dff70b0040323b6626c89fd661a43b66"
SRC_URI[sha256sum] = "88077675914a696e4fe07eb48bedff32b585a95a57c3efb1838035ff2a3fab9f"
