# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad6dd046463d4f494116281aafb9d702"
SRC_URI[sha256sum] = "7f1d6d6e53058bd1efeae229c97a0f9d3b596f8194f24be909345ecb63f960cc"
