# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f32681870ff8a37c934655401aef34a"
SRC_URI[sha256sum] = "efc4ede245796d1412e1d49092857835051c33367fdd4cfd252d57073e05db28"
