# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c0a010637d765a39ffccc1cc49306f4"
SRC_URI[sha256sum] = "752aac6ac6362ff160a295eb176578f25406295c5a362dcf3b3494fc676175af"
