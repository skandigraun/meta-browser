# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4743a57bf07cae8ee1412db02eaf707"
SRC_URI[sha256sum] = "1488d2b01df23c547b41c0e6a3803bd197d06860cd037990e603a9cc44d766e1"
