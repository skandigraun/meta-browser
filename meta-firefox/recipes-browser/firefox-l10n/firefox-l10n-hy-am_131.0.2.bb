# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "142bd001774e64c81bf92fc647253ca3"
SRC_URI[sha256sum] = "d975c36ef75beca95ed4d969e9c8f20b344f17b9d099480987459a4bc70a12e3"
