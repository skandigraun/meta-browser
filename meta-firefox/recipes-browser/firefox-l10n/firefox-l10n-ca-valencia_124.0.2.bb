# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1c0985e664fe9bc200db7f320895b8e"
SRC_URI[sha256sum] = "7520b053b4fb4862537504211148152d87248dfe1e1dd25611b610f729c65255"
