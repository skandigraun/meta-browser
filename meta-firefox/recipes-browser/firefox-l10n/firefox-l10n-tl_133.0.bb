# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55be9c81bbb3feebee6a48138d08949f"
SRC_URI[sha256sum] = "10e391da541bc2d095cffca9fdd8831f87bbfc378e48c4a1e194a71b2528c83c"
