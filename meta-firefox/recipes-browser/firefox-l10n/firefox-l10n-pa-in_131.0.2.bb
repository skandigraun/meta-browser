# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "730ba8b0dddc2e744848ce882b084164"
SRC_URI[sha256sum] = "260543617efc71fb8d475c23d6095aae421cd924b4a951f5b791e8cf39ae6d1c"
