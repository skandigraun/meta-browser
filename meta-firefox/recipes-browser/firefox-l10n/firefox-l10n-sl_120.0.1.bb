# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a084ea9cadfd5132ac8668f71ab55cca"
SRC_URI[sha256sum] = "7efd63e6ed55635917d6c4ab85087fe4d6f31435ff42ef06b0a3569ae1e0e3b8"
