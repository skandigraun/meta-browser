# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60e95cc31ecf1aa8e6e9bc6bbd60fed2"
SRC_URI[sha256sum] = "717bb16969bcc6915e459f11fb50077c51582e5d8f4b8e97532b058205312b72"
