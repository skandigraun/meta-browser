# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d986c5063cd36020e10b721f3de0b380"
SRC_URI[sha256sum] = "400ed72115076a16e5115dded6a2fa9b46a195d59bf2adc0e3abeef2b9738443"
