# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a129f2393120fb36c7e670ee6cc14225"
SRC_URI[sha256sum] = "f46dbfd425d525f59ca2729781e5b21bdc085f14537a8db8834c99904a1f8b2c"
