# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "21952f11ff068732ba872ab6e529e5fb"
SRC_URI[sha256sum] = "cf5fe3e8f49b5317e4b4fc6b803e81aa3d67bdf79eea434a0bfe0356d1ef0433"
