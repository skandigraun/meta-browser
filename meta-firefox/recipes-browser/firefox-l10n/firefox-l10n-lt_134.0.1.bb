# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bc54d4bbaa6ff32ee50fb29b767a871"
SRC_URI[sha256sum] = "e64b7ab0a5a02a7065a205e3ad01e74e60191f8e5f166bedb9d2581ccad466b7"
