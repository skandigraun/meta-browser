# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db753531c158d4ad6ee3baff99d6abaa"
SRC_URI[sha256sum] = "a0e3ba7f70f86c125d6198e3d0ce3aa5d9d6176cb803d110577b6acee3c04910"
