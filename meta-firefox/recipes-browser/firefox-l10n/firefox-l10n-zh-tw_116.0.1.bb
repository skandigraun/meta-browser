# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92c317b0195ce19a88d029ea257e4153"
SRC_URI[sha256sum] = "0d3a713c78aba40f11465367a7e87a8f472ec75505cb8c84eab82b4131bcf3e9"
