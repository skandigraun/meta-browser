# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "625b25f903d797fb3fea0262dbdd9553"
SRC_URI[sha256sum] = "68775903d0cb1932905dd5375e1a22f8df1c09a6b26ca9b0105b96952085811d"
