# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23017ee96dc485b6498a6a91d05b6e8e"
SRC_URI[sha256sum] = "39d24411e1d4a49edb7d023f83c7cdf2e4ee7efb75664541822a37c4e3098de0"
