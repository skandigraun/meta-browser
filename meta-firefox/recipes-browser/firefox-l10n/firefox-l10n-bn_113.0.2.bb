# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10d0105e4f7e86a19d3c3d360aa0aed3"
SRC_URI[sha256sum] = "b8d26e05556e1029bb08d335f5543a15a4b983a5e2d70da6f748237a3c73a6c7"
