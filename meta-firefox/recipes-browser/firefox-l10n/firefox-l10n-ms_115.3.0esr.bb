# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59f525d7ed8c855d48717d6fc90910ca"
SRC_URI[sha256sum] = "25a2081846486618b20c8d6dba5f0c2c7af8e6c82a25f78d71cccbcb1615ceb5"
