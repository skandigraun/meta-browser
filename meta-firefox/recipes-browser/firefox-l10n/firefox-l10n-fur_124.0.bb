# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33ec814f00c78d7a128712bb57600770"
SRC_URI[sha256sum] = "1c9ed6394448886cbd5ae549a072f586bb4d9648b8b2dd8789beb9a2a59ae25f"
