# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92464cd67c35a5a44a1c14ed2fc88a8f"
SRC_URI[sha256sum] = "e89a1962b6f5fe4f6508a31fe40eda3b2cf67d06ae103b89eca1b36a21c44eea"
