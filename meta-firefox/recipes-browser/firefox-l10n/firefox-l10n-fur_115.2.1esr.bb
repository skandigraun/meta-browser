# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a31c298b3468ddc7d0e5037401562487"
SRC_URI[sha256sum] = "023841ccfd34857db4e766b0ef79a64e319aa3efc88a553c749d95125e4755cb"
