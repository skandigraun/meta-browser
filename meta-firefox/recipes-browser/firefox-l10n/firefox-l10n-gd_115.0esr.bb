# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d619f7864b68775166bd3f63c628fad4"
SRC_URI[sha256sum] = "020dc5ba02d2b2fa9da34b354025b0342f1eedfa3b942bc67bd580f028689028"
