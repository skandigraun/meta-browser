# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "593781b2afb9140335b7c41bfd9a7b80"
SRC_URI[sha256sum] = "0d859098a724831ca901bfc6569c1a09bcbb6c49e1a3e9ebdbb32d48c8244705"
