# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7247c0d0ad20d38c99e67d81b16ef8b"
SRC_URI[sha256sum] = "5fa20ab8d1389c62ab64a48295e2615d16df8f13430c17a0287d99df92ff7b89"
