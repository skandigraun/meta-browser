# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a03ea312982dee4733ca9d3795b2a02d"
SRC_URI[sha256sum] = "b738fdce0133328f0956a42b22fd7b8ab987f6052e29bfa1873f6df1a49306ae"
