# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2238daeeeb06f31d27a0fce9f417d0db"
SRC_URI[sha256sum] = "39234f418913e95ec062ad1ab151bd6c547c4109113350cd011aa5d1774650de"
