# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7a17a1268cf665cdf51a55ee50b2604"
SRC_URI[sha256sum] = "2384481886c64ef366aa5d65899cd0832b235e2ed7d3527a9c5b4b76f2a34287"
