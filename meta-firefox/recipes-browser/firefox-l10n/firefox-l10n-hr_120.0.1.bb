# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c9a1bee25ae1093a73986a66f83dfe3"
SRC_URI[sha256sum] = "9fa656b2fa9176c971ae063f6d4b6b96b2ffff07f48a18c51d025430deb7f29f"
