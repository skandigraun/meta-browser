# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18f52dc710e360b8e666755d8d7a4ea8"
SRC_URI[sha256sum] = "928228f6a9fcb10259ab6959a4b55b6f761c14c4424ad007fe75cf626f06c7c7"
