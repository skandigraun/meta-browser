# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b01a12e6d3dc5e792e1a9759ec61e97d"
SRC_URI[sha256sum] = "f2885f75121f79345f3d8fb701f33d04d186c3af2d0945e86ff9855710a41e46"
