# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ceb8ab38f454a7a9eedb2af1213bf51"
SRC_URI[sha256sum] = "5b3874cd90d8b7c132b166a1c2fc86a20a2e8a90969c46e4a282614abc24eba4"
