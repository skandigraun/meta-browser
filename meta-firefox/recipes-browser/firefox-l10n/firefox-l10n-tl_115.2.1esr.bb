# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b1592d830019e9d0916fb174fa9a621d"
SRC_URI[sha256sum] = "47e6b3bb826f75cf935dd4ce01156ec7e75a354488815e39c0336ffcf142b99a"
