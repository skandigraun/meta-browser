# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ebee5893a814c5d233a38c339fa62cbb"
SRC_URI[sha256sum] = "4a1964e97ebfe93c84bcb8031d8c592337876c6a934098d865bc8d59eabdfafa"
