# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "367f0f1fdec32c52c923795f53144cba"
SRC_URI[sha256sum] = "e3b7cd7b9f23dfe54a5cc81c936a1b1b90ccc38a7e119678d52ac5044cebaa2f"
