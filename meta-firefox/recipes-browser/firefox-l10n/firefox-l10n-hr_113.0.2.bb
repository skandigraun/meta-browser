# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37db434cc2606f144f7f75f8d9cb678a"
SRC_URI[sha256sum] = "225ee3cce9252d242e89e14c1b1ed6ee45d68b67f9e0503733b053d5268a62e8"
