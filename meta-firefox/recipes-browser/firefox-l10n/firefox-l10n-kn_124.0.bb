# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9253444a875afee7679393d16d50944"
SRC_URI[sha256sum] = "519369e4ea1cb1b2f37d40f64cebe9c7a754c351aa98d5852f74c98ca4623db9"
