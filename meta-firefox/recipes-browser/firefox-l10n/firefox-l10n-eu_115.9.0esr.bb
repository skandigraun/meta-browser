# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ed1bf97f15a5428caa2784abbda54d94"
SRC_URI[sha256sum] = "e2479358f55868ecd39ad4080bbfa571f72293797d98730f6877a308393be8b9"
