# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "114a50ed451037120f818c9353461581"
SRC_URI[sha256sum] = "682764053e6f115a2fdf31519dff4e0e5d691a83fb55d12ec3ef15c889563509"
