# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3e42521d84ebb9e2e39da42b7948fb59"
SRC_URI[sha256sum] = "001922307d132b79ad9b0f707076c891fe063750f478e6aca4311822a824e107"
