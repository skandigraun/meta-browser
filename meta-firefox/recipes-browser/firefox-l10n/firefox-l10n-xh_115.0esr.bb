# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a676e3e76c7fba188953e8e4013b66c"
SRC_URI[sha256sum] = "b20a72ca9aa36fa20ad8ee77140f8928d4020e76b5262dc6d0c2dcaac7d8147d"
