# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2e0b37962da7b6848c61bb992d24e70"
SRC_URI[sha256sum] = "d21b27970746049db8bc3a06b8819dcd780d1af17eaedd0b5e9cc83cbcd0f293"
