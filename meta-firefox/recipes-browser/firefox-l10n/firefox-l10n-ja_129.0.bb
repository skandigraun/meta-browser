# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7c0619f25094b2066fcb051c0e705d8"
SRC_URI[sha256sum] = "a6083b69ecd1941c656f8276136783eeb3166f81cac69ccb968ce8860d925de0"
