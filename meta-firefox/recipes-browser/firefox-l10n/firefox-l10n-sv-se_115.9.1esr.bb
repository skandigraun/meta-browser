# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf740e9f8c6a7539c57b51aad669ed4a"
SRC_URI[sha256sum] = "ff45569fc0614d129727ecd50a596d3fe232f9b3dc3403c7d6fed848f367042c"
