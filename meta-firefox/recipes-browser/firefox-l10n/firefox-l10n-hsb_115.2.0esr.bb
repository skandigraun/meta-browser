# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4260b1be70194f095aca15066a55ffc"
SRC_URI[sha256sum] = "77edfcfe064aa05ca777f9fdb8b137c50fec66317fdd5e4a595ac1cb0277fe0d"
