# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c123d4ce280d0399db22e17e746734c"
SRC_URI[sha256sum] = "e2cda1e2bc9f68134f3acc9dd1fdf0be54640b2735d8f0ddda35617bed63b869"
