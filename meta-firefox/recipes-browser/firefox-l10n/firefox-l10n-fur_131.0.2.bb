# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d27d901dd177fbf52955a04cbf431ee"
SRC_URI[sha256sum] = "e95a179af132445b49c8695af02a439be993f088b34815bc7fb5b6b62a0c09d8"
