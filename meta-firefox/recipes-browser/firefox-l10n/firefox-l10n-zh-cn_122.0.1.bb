# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc41fd67b5d6ff80ea3d0f484e896c51"
SRC_URI[sha256sum] = "910bcc9fd05963edf95790b4320db0df315589e7eeb3c2f3d0c26c5f9760f367"
