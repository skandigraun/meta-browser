# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa64d1293f4048a0f1df010dc504bd5a"
SRC_URI[sha256sum] = "641c10ed2ddf7f937ddae70bc38257f435fe87c229a9309fb4915c9f9ebe7dab"
