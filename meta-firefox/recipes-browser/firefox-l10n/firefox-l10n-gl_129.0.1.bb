# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "268df096340df7e96814b6d5921f5d0d"
SRC_URI[sha256sum] = "b2ee63f739b9eb2f4e076ad5675bcd73fd6092a29722697164c5b54178dcb72e"
