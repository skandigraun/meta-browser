# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d9495a092ee21c1a09b485250048a88c"
SRC_URI[sha256sum] = "c355aa457e5709db2b7e5e9c50184131f7162832ce4b55f35140e39d0972d541"
