# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e978a0f8eb50969bf0839ffea5a5d615"
SRC_URI[sha256sum] = "394533b2f5c399d8803ce5fbba05a901f16eddc39b54fe602d1a3dfd2812cb54"
