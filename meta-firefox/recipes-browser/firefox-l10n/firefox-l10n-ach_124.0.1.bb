# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ccf1127174d8e7dd42511b81a5cb0b63"
SRC_URI[sha256sum] = "aaefc82caf4fa9068e9fab60a71ba8a33208067d030902f801a3e0a6de91e42d"
