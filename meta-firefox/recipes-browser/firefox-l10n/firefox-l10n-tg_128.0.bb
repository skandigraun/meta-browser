# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07ffe19bb3ebe560c4dde414839fd9c6"
SRC_URI[sha256sum] = "20dced64ab5c09a71bb4faee1c0761294cbd7bbe5de80f80b755dc95efb6c312"
