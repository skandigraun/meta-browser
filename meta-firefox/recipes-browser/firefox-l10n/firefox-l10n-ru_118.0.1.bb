# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2fcb41aa4b927d644123ae533a3f562e"
SRC_URI[sha256sum] = "b48ff63acd14ecf0b0542492a18c9de7bd9a07adab4709ed4617242f02c642ec"
