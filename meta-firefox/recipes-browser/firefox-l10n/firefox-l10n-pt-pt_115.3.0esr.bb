# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f05a655d482d4cc5442e99d37ed48b7d"
SRC_URI[sha256sum] = "98ef628594b3454a97a6475a892343260d983f02f4ddffff40fdde4836805f85"
