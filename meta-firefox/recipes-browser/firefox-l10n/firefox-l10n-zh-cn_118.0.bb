# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22ae9ea61506bc160c35a3336b111514"
SRC_URI[sha256sum] = "061d290f56823235222e912161eeb0d6edfda19d4ae153663c984fc6d057ac4a"
