# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "02e0e1c7feb91457ef77ae345fc204b4"
SRC_URI[sha256sum] = "4b559d090fe138fabc031b27b1cf5a0d67c0a036f646fa4430fe8c4c9f6b0e37"
