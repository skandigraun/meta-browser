# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9987dbc7d486ec7dedd29f00a67af4d7"
SRC_URI[sha256sum] = "9a4a0cb89ba419fa64392e30ddfd59b2802a6b3bbe70032db7eb8aaf5efd7c20"
