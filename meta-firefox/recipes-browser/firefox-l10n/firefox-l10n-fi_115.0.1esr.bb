# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d68249f9ec509feca0861c29986db8a7"
SRC_URI[sha256sum] = "a0f0387432d77f57e4a561fcc0388eb7eb08757167a13e4f22d2f61bf832ee88"
