# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0700e630c1357ae9a66c8678e3e4c728"
SRC_URI[sha256sum] = "b4a90ee3387624b1d4a0e1a8d729096c5808ba505c2e2253108e4c536ed717d7"
