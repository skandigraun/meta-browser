# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a9a17c9c6e89ac90aa30667071b02f9"
SRC_URI[sha256sum] = "9ef21c5364a2e488bfcefc1cc2a5e04681d3141a97c3158307d5343da200733d"
