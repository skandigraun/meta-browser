# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90025e0c674a770f0c5b445966c80ae3"
SRC_URI[sha256sum] = "87c9ad7f03b4c1721ff4cc6129bf80fc8f09b749fdee90da2249cf20992e3330"
