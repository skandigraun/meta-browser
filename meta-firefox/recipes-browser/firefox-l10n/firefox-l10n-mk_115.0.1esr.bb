# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cc4b96e367f3b471e924b378b273feb"
SRC_URI[sha256sum] = "28e7e5588887c60d47580eab7dd98c4e25fa15f20fa5e83116667fe9d52fd5f7"
