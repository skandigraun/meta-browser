# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "60aab85602c31347df607d451ac4a1e9"
SRC_URI[sha256sum] = "03bb330f8a9ce59f296771312ac7945829c745b7a60f402627fd0f4aa6b76e6e"
