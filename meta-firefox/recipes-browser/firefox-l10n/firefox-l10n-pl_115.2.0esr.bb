# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49f6e0937761e57b1fc6ca896dcdfea9"
SRC_URI[sha256sum] = "bb295fef2c0735ae419c9d41760edbf2baf104505ab91cdfcb4b38f58ab498e9"
