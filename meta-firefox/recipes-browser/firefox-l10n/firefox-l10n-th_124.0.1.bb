# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87e25a32f370f41ede48c650b678da7b"
SRC_URI[sha256sum] = "581d862a984e38561896aed2351e37739394c0b18cd1ffaa34ccc7c258ecfd01"
