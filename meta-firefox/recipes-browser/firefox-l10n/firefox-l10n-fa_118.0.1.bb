# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "10a4c12409e5a50e8475c4a10b8d5041"
SRC_URI[sha256sum] = "bf30bc711d2f5f53a0604539ef43ec6df0433849cc5ec73c881531d7c96e250b"
