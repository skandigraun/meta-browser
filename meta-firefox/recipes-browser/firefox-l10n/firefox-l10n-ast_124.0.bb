# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e193c9e04197a0001ef9614ddb0ef57e"
SRC_URI[sha256sum] = "28aa3a86dd7c90dd43c8fba72466d7368aebf8210a319bc58f819e5ef1fbd6ac"
