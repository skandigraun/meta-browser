# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f81be7254766fe0e11a34b41764d1f5"
SRC_URI[sha256sum] = "768b02dbe2f6849679c826f421357c425845cc6d345c390abbbb19605476b4ea"
