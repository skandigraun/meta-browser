# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7cd5473f8564c5b4d065b93aa99967b9"
SRC_URI[sha256sum] = "b0c6ccb871b6c2028c99f8b6b93b87a776b5dc6c7ba7050c409f7329e47e5995"
