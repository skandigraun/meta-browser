# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0024c4ff15df31ece8373f6360daeb0c"
SRC_URI[sha256sum] = "b9f7434035a9440321d120e88de52b8b0d04540a8b34fbf5ba5360455d413e06"
