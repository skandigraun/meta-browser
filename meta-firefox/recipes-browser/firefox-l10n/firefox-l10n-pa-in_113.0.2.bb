# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd9a1f72b95aa6f6573c88d8a24e673f"
SRC_URI[sha256sum] = "f453a156067120b904d2c1656f135d615696fcbf2304bdaf6466b68807ae451d"
