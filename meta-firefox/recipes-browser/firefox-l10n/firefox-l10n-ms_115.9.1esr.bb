# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffa638d4d4a1a8680beb5169fa846a48"
SRC_URI[sha256sum] = "8d8c870f9c32295076725f496586f84bf4d3ba3822f9335a19f18d0e5668ee8c"
