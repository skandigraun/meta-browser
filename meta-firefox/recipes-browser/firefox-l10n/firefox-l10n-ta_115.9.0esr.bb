# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cffedc5a286cf76072c77423c6c46ae9"
SRC_URI[sha256sum] = "5c72540c9b24a773930cad0a2c195cd94ad9e5719e3980457852bd2f9bbeb1ae"
