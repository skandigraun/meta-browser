# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c45004951c6c103966bacbc5bfa6465e"
SRC_URI[sha256sum] = "d8864fe923bfa4373d4cd48081ee74b620cc42c1ed89414b1ca0b490fe6481ef"
