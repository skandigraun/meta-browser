# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ffb2625b676c11e8db28d2dd0a9f0267"
SRC_URI[sha256sum] = "06b839464a5bcb566aff8cae0b304f154d6c40209e7b9707c691894e9febf250"
