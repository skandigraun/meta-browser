# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6cc0436e0156112d453635d9629fd54f"
SRC_URI[sha256sum] = "d286c2a2e694ede7330ec3463bcd41a0713ec71e39c9e6b4fd272ef510462dff"
