# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ad65e43164cde7ee89b4a7164125837"
SRC_URI[sha256sum] = "6bffa698e190eac8623f36dd7d3bdf2aefc88921ea92c6a9b4c2d2578e6cac74"
