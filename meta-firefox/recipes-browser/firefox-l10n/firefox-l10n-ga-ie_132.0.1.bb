# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "126eb20a7eee46f3f75d5e7a57569f92"
SRC_URI[sha256sum] = "9e54585b791720bdf96e2aaefbad8e745f90034e8529745c64251905a4640acb"
