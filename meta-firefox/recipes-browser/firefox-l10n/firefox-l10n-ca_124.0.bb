# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd907e408379a796ff7c63f7d61342dd"
SRC_URI[sha256sum] = "0f2963eb1696eb8e0f968ca1bade4c6884d0d6781ef03e3c3257de837b395f43"
