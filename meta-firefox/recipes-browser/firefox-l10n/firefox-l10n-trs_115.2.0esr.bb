# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9f8d3d1ccd80d88785b3f04e33551f2"
SRC_URI[sha256sum] = "8bfc36c3f51f31c37d7d1818646c162a6a241f0d240e7558075c4ebd9283c304"
