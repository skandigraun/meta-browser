# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "37af81e86bf8dc63113380db8c9a620a"
SRC_URI[sha256sum] = "b9997622a984c1277339961bff6b68114ffcd6a091475a0f1046300057d5ad98"
