# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "85c68d28cffdb9638f40de0169f3f3fa"
SRC_URI[sha256sum] = "50b5e4a735e6c43e08f4d4a1e8ac2b8efbb39050abd7b1d36e32bbd6884be468"
