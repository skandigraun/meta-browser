# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "449761ef56bb0d63c4c8cec3641987ad"
SRC_URI[sha256sum] = "39da2bd341d58d4686b2609772d2e40c04183a4046ef4de5bf02821cd550d864"
