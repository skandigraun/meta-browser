# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77df74b0fe1be5c1dcb23086ae138d58"
SRC_URI[sha256sum] = "dec9ff84dcb92e120580d9acd503ed0326369a2525d1144fcdd32a5e44b4f12d"
