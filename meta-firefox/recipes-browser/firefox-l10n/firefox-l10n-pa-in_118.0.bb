# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "357c28dff2a0c1ef69da00b052200b66"
SRC_URI[sha256sum] = "1f220f09b4ff32113ac4b4aab3c3d9e3f1be8128801211bd22e7d57bbaabca82"
