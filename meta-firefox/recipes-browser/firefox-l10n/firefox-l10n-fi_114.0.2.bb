# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa243f6e676fb38c6020e87a04240c78"
SRC_URI[sha256sum] = "6bbb1caa4488a94e67fa4902d7e042a47fa4c309a8f911d240a78c994915494b"
