# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "550b24e27c09b9ade8db77c28dd8ccdb"
SRC_URI[sha256sum] = "bcc67862eb463e7589a289ae4c707ef74f9f7e3f8a5c9ba8b7f9063cd89b308c"
