# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f13935bc5716bd66aad23f2b677aa82"
SRC_URI[sha256sum] = "bf3c2cb5702814726ac3286e3577bca996c21739b9e83fd285ddf9a3dd0993ca"
