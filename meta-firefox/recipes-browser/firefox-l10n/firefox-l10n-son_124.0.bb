# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12e286c9e079b5c12255467da1310c3b"
SRC_URI[sha256sum] = "fe80e2c1ef816b0b3a62a3ce99b6e0a2d853b15d1e36d595bf6482b24d7c996c"
