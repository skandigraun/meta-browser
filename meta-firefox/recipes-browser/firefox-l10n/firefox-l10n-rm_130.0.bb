# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65454a483588d98a5248594edfeffeb3"
SRC_URI[sha256sum] = "dca339de6d84cae670a7d41967dc7e84840dfa0a45413fbbf469b1a8c0345233"
