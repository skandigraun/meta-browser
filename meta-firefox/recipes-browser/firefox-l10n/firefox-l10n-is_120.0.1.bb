# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea07da5f7c3c966e619ee5379c559094"
SRC_URI[sha256sum] = "178190240768234f9686cf72dccf5ac4c959ea5558b253e6d7ad4fd9c445e65d"
