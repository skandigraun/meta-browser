# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3babab7bf9b798e23c1aa8468aafcf16"
SRC_URI[sha256sum] = "0b27ce7aa8ff4b09d5f42c1525d89505d2b159c7d9051b3e1dcb60ed67a0be5c"
