# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b04e8312b3a7bc1711a4d43dfdae6733"
SRC_URI[sha256sum] = "bf2e7958daece47879a3861de236a5a1377f512151221bf515f3a54140861384"
