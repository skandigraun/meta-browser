# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "157c397a1f4defc56957f49a8a455842"
SRC_URI[sha256sum] = "69f778a4bef657293818043261ecc8ed07518220d14831c5ddf607df6e20eef1"
