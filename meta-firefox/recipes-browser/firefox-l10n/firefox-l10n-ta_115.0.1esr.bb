# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b2221def8ed62a6d94a111dce8a87cd"
SRC_URI[sha256sum] = "40e8d51af7c15997bf53c8a355595169ff684e4f2d374f5d023effe216895f19"
