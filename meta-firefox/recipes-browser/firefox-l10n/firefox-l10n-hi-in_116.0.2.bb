# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc8803ec31a10ebc8e7f798014f55798"
SRC_URI[sha256sum] = "bb9f333fa51e32c3deb276becd6632f34c8e30ae5819f169c5f3364c0339e945"
