# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9121c21b9fa4143700cbe954d1f175d"
SRC_URI[sha256sum] = "e26cd2ae76ff2ad38211ff99231f4be4c4af15241a2068077ed14e69ddbeffa3"
