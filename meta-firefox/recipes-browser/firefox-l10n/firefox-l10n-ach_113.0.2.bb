# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23d439e3ea92aa8fcd5c3ad2a6f5a3c2"
SRC_URI[sha256sum] = "317c21445e7b2f3e54d66da8c1d77359547bd648eeb4b59329de056cb6253994"
