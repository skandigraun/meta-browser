# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cdebcbd2f9ea10eec96985005a451063"
SRC_URI[sha256sum] = "c44a068d2d4af9130a64e21d233eb86b2cb32c3c82b79f27557619a04a04945e"
