# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3424260f7ca98c4a00c931f49ae113ae"
SRC_URI[sha256sum] = "366ad5e36ba59c0b63fc31ff61422ec8b7ab28e395a684a6e2199b9f512926c6"
