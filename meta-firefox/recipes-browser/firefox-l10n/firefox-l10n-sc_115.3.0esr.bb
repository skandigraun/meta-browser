# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c5a1a4dfcc678e49c9e42205f5b2633"
SRC_URI[sha256sum] = "dca5a8c4d9d20ee42ee663a7f55d8c56dd4c6cd9325b76d3ad6d0cdafb13d5b8"
