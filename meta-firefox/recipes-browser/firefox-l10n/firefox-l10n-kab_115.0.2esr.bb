# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1caed04f39ea16de59af0cab306128ac"
SRC_URI[sha256sum] = "7591fde70893f5fca393e20a042d8770c570a4737f5c9c5f6bef3217d6a15f8a"
