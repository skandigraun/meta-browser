# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4c49a6717e5ecb448798ca0a3f5551f"
SRC_URI[sha256sum] = "e0dec38f3a0e97972976135bcd96ea57d635988e2025bd5449bbe3d990e279cf"
