# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e5248fc2232eb8b07523480ab3c70df"
SRC_URI[sha256sum] = "7d1c390519f431f906b32526177b8ca76807d8dd8ea0c05ac86510cd03eeda38"
