# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "389e02a8d0a6df137687162d1f4c4479"
SRC_URI[sha256sum] = "583fb62436d39bedd6a460bc2894ad32b90cbb92dfb22cb74a1db001638f6cc9"
