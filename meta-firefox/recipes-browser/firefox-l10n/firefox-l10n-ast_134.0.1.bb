# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27da9cedd02e1b2543f0f7c165e82a1a"
SRC_URI[sha256sum] = "180e42b53ae49297cbde8c457523ca86ea4a4434a66747a94a35329d4f3e506c"
