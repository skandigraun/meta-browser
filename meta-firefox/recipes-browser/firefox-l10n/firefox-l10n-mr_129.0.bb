# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da82f78bbc65588bfbf7ed8991e2b856"
SRC_URI[sha256sum] = "2144dd04e237d9b86c9bb00de7e5a68e5be5a00974dd0dffa1c5ef84c48e77c4"
