# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcd683c55dfc870f9c03bd590608c08c"
SRC_URI[sha256sum] = "6ded563d8f5ae096ed6f3c58dd19277333dae81fda96832a50a5040ef79ca35b"
