# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19d83f1119bd2bb96f574352489676e9"
SRC_URI[sha256sum] = "6009e7195cca4d42bb80a8e48d54deb554284897ed66d1cb2bf46ad944e10a58"
