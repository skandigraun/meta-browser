# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87649c4842946fca996f4987d5e7aa03"
SRC_URI[sha256sum] = "9dd8737540293381afdf8a6a8c33259e695bc3a6beb4c959b41a783c91f6e80f"
