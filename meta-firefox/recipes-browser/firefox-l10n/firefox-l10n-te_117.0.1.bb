# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2077aa217dffd56772a7b222291164c4"
SRC_URI[sha256sum] = "d2ddfb703d947e66a91cbac7970e41871608a61b48a827cbab8585242c67726e"
