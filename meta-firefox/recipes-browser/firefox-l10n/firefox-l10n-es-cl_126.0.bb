# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9df5b9fad58fbe19bba589d154cb9507"
SRC_URI[sha256sum] = "29b76d36472fd2e3a31beb7163465603694e7537a57dca6ac228f77528c3708d"
