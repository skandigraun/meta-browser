# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ffee96f0ea510d8e312bb7a331a6d6a"
SRC_URI[sha256sum] = "ff4ffc3ec70fd6aa037e3194c03773c540c8707b35f71a28c0561919e323c81f"
