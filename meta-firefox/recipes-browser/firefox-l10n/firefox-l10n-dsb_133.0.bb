# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b0c92ace18b20167a6093819f99cb90"
SRC_URI[sha256sum] = "224f7b32a1fae20306eda1329db2894b0af9575c77324637c3a49f34805df19f"
