# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "058c84b55a421d835a998ca3902cce80"
SRC_URI[sha256sum] = "be68bf3877ed78292689bc79216dd04f3807fefaea530e8ae0ee91a47c48bd8a"
