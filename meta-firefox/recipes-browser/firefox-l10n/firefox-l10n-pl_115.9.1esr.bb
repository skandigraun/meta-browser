# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8f43d72cb10649d03702ea33470568a1"
SRC_URI[sha256sum] = "04c2f25d6bcaa7757fe7cad373ef35e710f32602f4bda7df52fd576411b4430c"
