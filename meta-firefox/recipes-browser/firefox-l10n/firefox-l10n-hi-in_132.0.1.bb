# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd5d38028839c54631ae8f92c6b1f26c"
SRC_URI[sha256sum] = "4cde09fe70080a2a41de8d3abfaca0f5bd90aeaf7fbc679606f35f76260c2782"
