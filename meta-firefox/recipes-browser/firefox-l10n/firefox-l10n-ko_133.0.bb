# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7875b0c1fcd8aa6f8e6626cc09cc306"
SRC_URI[sha256sum] = "539d7b1bccdac2ca583bbbe0490185235e8ec835af5f83722d73618b7da74b0f"
