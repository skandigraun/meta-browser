# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8fc5b10c26f74fc781ad2c11ab48abf3"
SRC_URI[sha256sum] = "b41345ff43faddc5821173d857b469b36f2eb3d4d079332daa0b7aebf76c69d5"
