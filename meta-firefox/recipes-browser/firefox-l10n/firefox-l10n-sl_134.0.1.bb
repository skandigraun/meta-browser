# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0544433e40c74acf9c6077075609ddb6"
SRC_URI[sha256sum] = "bd736fcdb58f2807f7501b56c9d3c6d07f5bd3fad77d15d2e8a15f284e052f92"
