# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41218163e13154d48ae6c2bac2cf3e81"
SRC_URI[sha256sum] = "fff23072e41f6282f02547e816f531536a97b8fe8d9a1a0443d4797958262ba6"
