# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3bc109d473db306452eb41775930446b"
SRC_URI[sha256sum] = "704d3e5c82a5d0a2d7e426a7a8f2969f1758e01d9bc5a71a7e16bbcbd935d401"
