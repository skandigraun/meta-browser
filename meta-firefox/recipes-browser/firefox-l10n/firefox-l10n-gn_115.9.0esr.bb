# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d50401eee1aff986a951d84747bf6bbd"
SRC_URI[sha256sum] = "377e459d3e0998990aeea76e015e1c9447432fcbcf3bad704ac41819cb6dedf3"
