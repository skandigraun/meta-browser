# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "79c0eea03d89c71589a5c0b198f060ae"
SRC_URI[sha256sum] = "f956a7a0e3e11332aeece3c61ce0ec4163b99d8cd9f72a15bf06628a6928bb39"
