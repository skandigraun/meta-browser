# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3591368a5d110f5fd26bc3f91869371"
SRC_URI[sha256sum] = "3c73db859666a72ce0a23ca47407ea0761dde65def829f1cc31784a05db493af"
