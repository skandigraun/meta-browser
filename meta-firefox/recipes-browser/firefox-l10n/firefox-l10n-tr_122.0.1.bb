# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd18c4fe85a02a030449adb6f256dd5f"
SRC_URI[sha256sum] = "b05bac0916f2d7ae8dfef8fd745fcb7a22c40a7d90350965dc1d9cbcbc2fb882"
