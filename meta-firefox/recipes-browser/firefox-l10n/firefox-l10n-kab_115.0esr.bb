# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "de12b851892a97d8c66c9686b2ec25ab"
SRC_URI[sha256sum] = "5bd5238d99245d5047ad2a183be1712c0b0c195e086915c63a0655a0e4e8ef67"
