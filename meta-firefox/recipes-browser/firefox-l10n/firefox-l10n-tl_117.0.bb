# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23e70ead7e13419c047b455f2e071513"
SRC_URI[sha256sum] = "74c56f567641ca6c655935dc7bf4c7f80e281d960effbc412a1d700310ebba49"
