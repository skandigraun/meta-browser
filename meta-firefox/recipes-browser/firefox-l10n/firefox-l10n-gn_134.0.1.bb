# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "59dd95601c435c9a9d33045f56751ed0"
SRC_URI[sha256sum] = "572943b8d2f336666eedd9b9f27a34d2bed9215a4c4325a103903401503a7258"
