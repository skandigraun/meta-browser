# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8962b992eba2ce1a483325e26f771641"
SRC_URI[sha256sum] = "850c94d378eb41a08de0e1be01605aeedb973282532bb7a85e9ac7a870998f2c"
