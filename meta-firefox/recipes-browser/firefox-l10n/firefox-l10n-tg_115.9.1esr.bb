# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea35e71c6186bd8994a4d682b9b0d23e"
SRC_URI[sha256sum] = "4bcc8a655f1c44e571283f2677696f3fca1398d7c9eb2e3ccb6fc2df647bcf03"
