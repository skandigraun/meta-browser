# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86a433f09eb5581353c0419c6151252e"
SRC_URI[sha256sum] = "c54066408fa458a9e204ace37cf60012dc79ea7716e12821f1ab422d5f7f30cc"
