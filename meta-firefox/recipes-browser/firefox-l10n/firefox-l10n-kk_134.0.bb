# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1576fb77ea4d65d4155b892451f6e2f4"
SRC_URI[sha256sum] = "22aba14c2752bbf86add1f31140fb962de9f7eed0a1be6f39a73bca4fab8e05e"
