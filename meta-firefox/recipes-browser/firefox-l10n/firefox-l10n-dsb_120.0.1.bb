# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "366aae63c70c39b99fda21deac68280f"
SRC_URI[sha256sum] = "a694c1387579d51555d8cb039b64b04909c6c729092c2e8f6b543107e0879c8e"
