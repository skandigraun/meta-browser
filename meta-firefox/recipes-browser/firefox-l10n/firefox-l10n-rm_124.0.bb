# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6e14dfa0117b24235e2d018278caf3db"
SRC_URI[sha256sum] = "49128d812737da5c50645c0843ab9439d8e37d1d55c6fdddc95688b2b13b8ca1"
