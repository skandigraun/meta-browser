# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c67ca975920fca04fbc7a58f054ddb89"
SRC_URI[sha256sum] = "d932a98a89d1bbd59e0409f393eef05925f4a3e9d39871a4664f2871f477512b"
