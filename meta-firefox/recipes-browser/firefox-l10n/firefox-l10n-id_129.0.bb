# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa00a13178259f758fc6c300fb5688c3"
SRC_URI[sha256sum] = "0cd106aa8b6fb6b63d01b2bc1a1c15335fe529ae4c1fb78201bba935b1028538"
