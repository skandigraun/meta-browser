# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a99eccd3e71e7e81261e07f398e4083"
SRC_URI[sha256sum] = "ee9d7e16c5fcef514e9d6d09fe2bd60d932ca8f74cfb5c93992eac8c850ca36c"
