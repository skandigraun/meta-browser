# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19224cf4fd332beab8ae0952f40b2a9a"
SRC_URI[sha256sum] = "6ae5240f448f544d8cefaca90b718d621bc0dc45bc44447e83d0a2c22548b736"
