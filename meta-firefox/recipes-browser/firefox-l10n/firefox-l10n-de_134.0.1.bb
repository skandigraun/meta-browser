# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d1e4d2a0b2d2a575d7ec845da6f9518"
SRC_URI[sha256sum] = "f7df0497cc9ad3be6cdae9924c0527b3de6bf57a968cc517908f37c98c1f886c"
