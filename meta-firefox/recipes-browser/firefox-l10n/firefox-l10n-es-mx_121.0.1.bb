# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "285eaaf881e3235761bdfa8838dcc9c6"
SRC_URI[sha256sum] = "31279b7d58046b48fcf7722d3e98f8a38eef99f4ee39084f03348aedab5d84a8"
