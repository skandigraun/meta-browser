# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ab98fa58012bb0a504bdb00cfd8522f"
SRC_URI[sha256sum] = "d45187289f422ee1d3ec7edac32e41ebfd70c750168382c315abf92567aeddab"
