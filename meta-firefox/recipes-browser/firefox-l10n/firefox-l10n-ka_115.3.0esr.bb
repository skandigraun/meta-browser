# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ce3fe048144060d714417772c668271"
SRC_URI[sha256sum] = "f978dc662b270f294529d2f37eb0d48a3570e2a39f0217c0bd67c1574066a29b"
