# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0059d36c67d1aa6e06093f155a7c745"
SRC_URI[sha256sum] = "6489e0defa8c5ae35e7093877d0ca449ba18d62870a5fb4f0e433b06688807b6"
