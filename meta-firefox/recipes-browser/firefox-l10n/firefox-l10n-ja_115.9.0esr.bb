# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "797b3164be6dbf5cff336c01263b3b63"
SRC_URI[sha256sum] = "b23b4e62ac464987c610a578b6b551a042c6c4f6011023208ba75c669e268f50"
