# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "105dcd89cd3554028e44ea8d9e20523b"
SRC_URI[sha256sum] = "8e4d50c9476dfe8e2622ef6ef73fd4f24a257e02350c494589746af05a4b681e"
