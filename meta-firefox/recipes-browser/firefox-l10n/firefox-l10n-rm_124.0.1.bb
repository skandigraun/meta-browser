# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e9d5b76b154a72c112188be3bb3a0e5d"
SRC_URI[sha256sum] = "0bc08070e0584b82c3b6bb65ef00c796bb9118549097a3527da8fae634ba384e"
