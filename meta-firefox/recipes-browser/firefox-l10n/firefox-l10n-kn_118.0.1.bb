# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5b73c277103e5f57b8edc546d4f42e14"
SRC_URI[sha256sum] = "50cb50fe5a98d5d1c20fe8133c8a9d2a2f30bc572352c632d5646f52eb38142e"
