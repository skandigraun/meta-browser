# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3930d896171a5b1a8279760bf9f30e9e"
SRC_URI[sha256sum] = "543ba26bdf04e00fd93b71b33843c7d3cb63e72d79e7f15da20c48b5c09f6783"
