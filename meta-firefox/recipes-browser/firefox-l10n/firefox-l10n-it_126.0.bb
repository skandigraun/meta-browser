# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a55bb6de22f1c8addcaec2f0cba37685"
SRC_URI[sha256sum] = "d3f7a95b1d8eebe412d287b00518cff93a3458d0f560cf82cb720c1ec4493534"
