# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e12602b5a861974bf0144eeecd0daf56"
SRC_URI[sha256sum] = "a1b894e1f42aba4d61d864c7865e791c3b9f13313118aa866a08282b1f5d217a"
