# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99cdfd0c55b25eb4b023fb03848b4216"
SRC_URI[sha256sum] = "04187731eda9c775bd278e2e5b840eec413187e5134678a0804abc2e24b7124e"
