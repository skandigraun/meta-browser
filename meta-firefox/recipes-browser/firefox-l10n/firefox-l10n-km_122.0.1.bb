# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ca91bab7ff4d09f34aa367a8b3c114ee"
SRC_URI[sha256sum] = "d0bb7aa5679011e457e9506644c4b3c0d33ccf0a3f11c3d603b29a566452a17c"
