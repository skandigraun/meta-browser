# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2190c6540ca6e6b7c4ade2d81cca0af5"
SRC_URI[sha256sum] = "85ced14d1fcf4a56be4ba38b2e510f162aa895b33a31c0698898e2cce3ddafc0"
