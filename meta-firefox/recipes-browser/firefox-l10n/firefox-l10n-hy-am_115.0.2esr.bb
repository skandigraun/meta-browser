# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0b50a361460117c1d7d1fcef11d18e5"
SRC_URI[sha256sum] = "332742f7a38125b643691a469575094d3379b803e54b6941ecef1116a57ac8b0"
