# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d78fe6ab416f861f214ecaac926bc7fa"
SRC_URI[sha256sum] = "12add1baa9fda4ae9c680da446f71e5ad5ef4c4e264f43db964c368c18b94c95"
