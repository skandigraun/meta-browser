# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e69329d38f1fe65abea31b2594648b1d"
SRC_URI[sha256sum] = "1ff24bec8e0e37e7fbd3105133a91df8760bc6a792a932fa3a0e9974d3f9a025"
