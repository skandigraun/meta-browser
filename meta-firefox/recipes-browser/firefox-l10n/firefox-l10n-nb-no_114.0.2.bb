# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3be97a8198d8ef4edc6601c243b6f8f0"
SRC_URI[sha256sum] = "bd19a2d1f161ac49f496e8b1f8c7440a511a5a841fc6642b6cc014b58612d1d3"
