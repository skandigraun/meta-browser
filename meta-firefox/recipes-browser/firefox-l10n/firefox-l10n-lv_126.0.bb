# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6047c4d42c01ca622ed88fccd489710a"
SRC_URI[sha256sum] = "188c4d8d325f2e99bef2930ce994c865b46ef5e6c697445b729ad821f1debe19"
