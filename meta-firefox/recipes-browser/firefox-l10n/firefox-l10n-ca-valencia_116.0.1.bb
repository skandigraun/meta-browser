# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5f038fe1b932509e2c8a147284c2d747"
SRC_URI[sha256sum] = "4a1808e2ba80a0301fbf686ae47cfef5ef3f85f18d69ae388d145f99562edc88"
