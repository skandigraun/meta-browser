# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c950db87bc9f6b5195acc89751c3c35"
SRC_URI[sha256sum] = "5d5e4c144e147b75b0d43837d793cd2617e1361327838f975606bbfdd3706974"
