# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "573cda2a6914072fa76729184c356137"
SRC_URI[sha256sum] = "a1ed84262a3ff95e4bd474706453b40d16da266b7b0cd789f11531289989da2e"
