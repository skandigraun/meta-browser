# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e08bc2ff04e087a81b570d9b0b5ccd79"
SRC_URI[sha256sum] = "db5fe02b314602c0131282bd8906a0127b1c7d4b31fd6da80eff3b76f7c4f48d"
