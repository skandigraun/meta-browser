# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1efb4d0db40664fa5d17d659e7fced62"
SRC_URI[sha256sum] = "ab3db13556384cd80fb95e70dd8333d7e7a17b7c8bd62cc16b87ae24b7acad6b"
