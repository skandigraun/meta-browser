# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "13c989b57bc81d6469ba3f4f938118ee"
SRC_URI[sha256sum] = "1630b68949aabc8fdfaf6629b449d748687569ebae9e306550f8d2b7d446fcb5"
