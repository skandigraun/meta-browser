# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b0c49b4343fe0f1158d4e7f2ae083aa"
SRC_URI[sha256sum] = "4bd0b5ac6052a72d16fa6177a31e1bd63a71132f3f41b900961255c593b889f5"
