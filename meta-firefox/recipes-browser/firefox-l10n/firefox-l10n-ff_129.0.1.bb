# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8cd0d477d226ff8bc82cd82339cd1a6f"
SRC_URI[sha256sum] = "d4ec855bd4e421cf5695fb7d4936cbb86127c9fe14bab3cc7457b33a8ceba5db"
