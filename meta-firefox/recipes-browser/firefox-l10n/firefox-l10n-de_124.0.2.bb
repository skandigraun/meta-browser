# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20437d406a4a57119e001a1246df23e5"
SRC_URI[sha256sum] = "34f9fb0909e208a3916586ec99c681a9d245927176c82eb970910b74be0fec88"
