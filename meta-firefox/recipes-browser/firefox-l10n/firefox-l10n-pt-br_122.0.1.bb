# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "66f8eebb9dcb6a88b8abe4f493619b24"
SRC_URI[sha256sum] = "89be36bfa239b870b1341d78a7819f5db2cb339a6b06f0873160d812a0bbde78"
