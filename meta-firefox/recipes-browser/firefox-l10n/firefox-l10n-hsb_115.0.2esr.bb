# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8133288ef6ef49a9444faee7d6aa695"
SRC_URI[sha256sum] = "dc3e7b4cf895dacc403a1eb66ecb54095b7642d853d9cac7a71d83698fd20fa4"
