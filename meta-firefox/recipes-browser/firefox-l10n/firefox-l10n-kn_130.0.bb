# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c295cdde68b845be480b0da90b9fbec1"
SRC_URI[sha256sum] = "a48dc6a092c183f404c77a4f907da027ddefc37989dc0d5de5bd941e41c4e136"
