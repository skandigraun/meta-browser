# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "18e284b0da723d4a82e94e2b8d173d6d"
SRC_URI[sha256sum] = "d5f85ee14f1c372e5ed5e57d6a07d39321598d30ecfd22dd47e801d67420a2df"
