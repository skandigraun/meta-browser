# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1601826acda7234b9dea062f2ebe54f"
SRC_URI[sha256sum] = "6a1fd174df2343abe8a74f219c32cbf457f3914c0dd3c96949d947dedafec8b1"
