# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95a1a6beb8c357eaf07dc91249b83ec6"
SRC_URI[sha256sum] = "055b778b89033cee0b8c382192b238040fc2f15d40390a17f9c023446d7b30b8"
