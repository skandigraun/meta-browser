# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cf7685049a4bd23387bcfa162821a657"
SRC_URI[sha256sum] = "8177275e5b0bb2f01c03a20533d7d817d842c6e53884f672eca8119037d4ccad"
