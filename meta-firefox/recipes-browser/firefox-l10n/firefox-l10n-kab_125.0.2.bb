# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8ebc57aa52ce87184fca6ecf87816494"
SRC_URI[sha256sum] = "ec397f5a137ba12cddddb7e9746f2b84f9fea916a3a79a659748e3e531df7466"
