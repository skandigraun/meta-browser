# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d71e2b69ff5bf4a1dacf625e38e000de"
SRC_URI[sha256sum] = "9818315d51eb9e25b7eb5fb02e26935be6ebbef587b34b6c7b1d730e15d1f8f4"
