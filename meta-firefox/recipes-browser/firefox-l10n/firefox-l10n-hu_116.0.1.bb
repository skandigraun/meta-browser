# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "daac2dafb022d4b0bd1fba54d653046d"
SRC_URI[sha256sum] = "6716c3d1e736bf6b5d9169ada6449b3ccdf229a921c833b4b63a022a9025b893"
