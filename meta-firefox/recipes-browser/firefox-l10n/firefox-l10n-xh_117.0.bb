# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "35655d7e5ba0c9d5b940a182ee197c91"
SRC_URI[sha256sum] = "bf67be25ba9df792887acf935d624a6112ef476755366564e2813e60907c2bb3"
