# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "860785c7774086653981de396a3622ea"
SRC_URI[sha256sum] = "2ed1596350eb615b4a802a02ca9ce269bfe5216708e2829e57e450ee6e5c367b"
