# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8e60047c91627aea312f612a8c0b9d3"
SRC_URI[sha256sum] = "ec3def772c481b7985e2bf0117ca443d292ce8f48dc041f517ff5346ff36e769"
