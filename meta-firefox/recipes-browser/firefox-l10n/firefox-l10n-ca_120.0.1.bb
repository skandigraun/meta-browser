# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a4f8f4d98e06170f98c4bbf52ccae32b"
SRC_URI[sha256sum] = "9374192fe6d35159c8dcac05be40faa1c6b83f041c0c57c1487b0deb319daa5f"
