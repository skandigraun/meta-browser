# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4d98e821dfc99097be80444173649b1"
SRC_URI[sha256sum] = "a0fa4b8a61ff661aef42ee86261b6a440fe147c8ec2b5b6d74c742cdbaf3e175"
