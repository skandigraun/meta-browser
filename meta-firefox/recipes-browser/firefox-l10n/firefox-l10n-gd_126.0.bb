# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f02c3fc44338b61e67201978c41f91f"
SRC_URI[sha256sum] = "4b4d3ca92dafa90fb1a955b19867454c4fded254255d5433c679933ed92615f5"
