# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b19f4cd007c3bd74db83de9b74e0062c"
SRC_URI[sha256sum] = "809a9aa5f12105a489700694d78a7db6bb0f4290543c0af8fbae63e2d92aefe4"
