# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5278c491ad54b397fc9ad22b15291aaa"
SRC_URI[sha256sum] = "67a70146e900e6aef8988bf78235fb1fa38262071be7cedcb72276e7836abd07"
