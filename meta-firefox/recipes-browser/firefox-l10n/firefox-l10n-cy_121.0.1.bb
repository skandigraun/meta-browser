# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c0dd8df9700bdb49999815e9df45eca3"
SRC_URI[sha256sum] = "b3425616c8f841fe91c27a3e994897ec05cf31b0f460a4bfc817228bd533e509"
