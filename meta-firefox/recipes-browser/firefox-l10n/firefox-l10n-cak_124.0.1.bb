# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c3623972c3bf8825a90c57208164292"
SRC_URI[sha256sum] = "33fe81429ba167c0ed4642050e874989c02ebf7a1ba2fabe0b89a839441690d3"
