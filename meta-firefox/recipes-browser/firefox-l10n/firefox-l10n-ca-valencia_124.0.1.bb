# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30a3c29bfc5aa27e2c475b38fcb00937"
SRC_URI[sha256sum] = "38c6de0c463b8100355c1026d4436755946eb8918d626c6568ae325b254fc385"
