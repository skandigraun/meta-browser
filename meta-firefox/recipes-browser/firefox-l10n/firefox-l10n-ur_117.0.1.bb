# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8476c14ff77d34623be4c21766d24fb"
SRC_URI[sha256sum] = "0b8a8619a1cf05b4b0b8bcbff1bafd21fcd1e022a9edf709a694e7e1754a4f28"
