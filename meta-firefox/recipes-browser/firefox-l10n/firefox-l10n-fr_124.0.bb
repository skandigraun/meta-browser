# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "41b7cd49f11f744cc01b15e204507402"
SRC_URI[sha256sum] = "3b74e0d9b1682c2b9a501fae4fdf7e0e5c4307ecd77db0f195aceaf0905e92a6"
