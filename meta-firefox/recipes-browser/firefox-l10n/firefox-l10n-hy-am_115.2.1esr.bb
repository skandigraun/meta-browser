# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4070294aec0a865e8e0ae5ebcf2e3cd"
SRC_URI[sha256sum] = "e0f379dda4c2edeb792daf93dd49f53b605edbbdab1d969e00ae1861576bb694"
