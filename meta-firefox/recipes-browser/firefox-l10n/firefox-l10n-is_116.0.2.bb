# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee3d4e49f6ab1d0ac40439b687edf765"
SRC_URI[sha256sum] = "ad220423aa45ff67f22254ebcf018e3f9adf2d417bb42311593842b345bff204"
