# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c411f19118fcbd62412074dc7566315"
SRC_URI[sha256sum] = "4410182a8b2e8fce2a65145fe6f5f12641e8da915d286eb5829b4ea61629453c"
