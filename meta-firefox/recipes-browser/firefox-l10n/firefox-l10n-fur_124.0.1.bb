# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97f63817dfe4aae6ea54fa9945264478"
SRC_URI[sha256sum] = "9c7e20b8ac126983bfd8a202ed807eb2bada5a5d858cdba265c880a5148dddf6"
