# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af8df9fe3a433d93c3aa61d698a847f3"
SRC_URI[sha256sum] = "e1509bae59ea25e26cba4ee3d15eb9277663d8c6298610ee036b0c8a7c4d69d7"
