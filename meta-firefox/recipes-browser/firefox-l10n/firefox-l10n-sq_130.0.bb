# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a17acbdf01d6907c89b2f7fc86b036db"
SRC_URI[sha256sum] = "c6c4e34f00a38003e7d5c08400990fbf5c8d0ceaa5242c5f86cfc6a3413b7775"
