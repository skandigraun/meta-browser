# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "883271d657c43990da572cdfa4e559d7"
SRC_URI[sha256sum] = "4905cf442f53a9dd41eb8baa515d7dc611233c5a220b26fa6cd3270220ecd3dc"
