# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7c8dd24df36078645ba25108cfaed984"
SRC_URI[sha256sum] = "8906aa0032fc1f064fd396aa72697857482364729189464a3019f9b53098c690"
