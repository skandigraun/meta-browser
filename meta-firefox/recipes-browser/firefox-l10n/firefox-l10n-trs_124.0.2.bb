# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5c16525f09ad996e19f5fd989a462d75"
SRC_URI[sha256sum] = "260278ef645666389a440a1a056c11a6bf84cbd189634be6fb835455992c41e9"
