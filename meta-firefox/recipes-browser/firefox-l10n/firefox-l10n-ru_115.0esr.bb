# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0acc82a3883bb0f06d404a61b88f0b96"
SRC_URI[sha256sum] = "a9afba7b190b7d503758778f83374a1ef7befed47ed14c70c2ce1c6ab2e95d2d"
