# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a1bbb0b637ef827e9d490b734148cffa"
SRC_URI[sha256sum] = "f3c6f5eeb4a85e30c3db0ab6f128bf3ef2e0427468954462c92c97bd4cb010b9"
