# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "abe1b04328eb57b049c5b8de6a606885"
SRC_URI[sha256sum] = "2e4da10439db8da6c934cfee5e91d8bd7476bf6aee3b2b2222494f842aa80df2"
