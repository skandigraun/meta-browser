# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0acd03dbd843e736090a50569f218e7e"
SRC_URI[sha256sum] = "3ff1c232aea518ab29e45d384f0f0b1d15f1ecda6579be7852603f5da798eff2"
