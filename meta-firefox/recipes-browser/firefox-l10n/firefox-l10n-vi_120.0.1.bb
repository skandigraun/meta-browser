# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0c40242a70faad440159ff164abd28aa"
SRC_URI[sha256sum] = "3e66f8c1559acbb7861968c7654267f9704099379eeb8e8f6ee53c7471a75e48"
