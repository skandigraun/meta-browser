# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1795a4c2d3c33d0f9c9c55a165aecaa2"
SRC_URI[sha256sum] = "e68f3e19427ab50a53282013b0f43f620554abaab7dd83410d7e9ba177eb5811"
