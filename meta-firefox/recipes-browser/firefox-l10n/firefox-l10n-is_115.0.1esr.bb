# Copyright (C) 2009-2018, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d296808725e5af387295532acda75e2"
SRC_URI[sha256sum] = "c278e4ff9f5efdffedd365ed608da3dd2666f6ad43c21853dcc08af2a5962516"
